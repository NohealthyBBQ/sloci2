v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {10u} -930 -1890 0 0 0.4 0.4 {}
T {10u} -1140 -1890 0 0 0.4 0.4 {}
T {100u} -730 -1890 0 0 0.4 0.4 {}
T {10u} -930 -1410 0 0 0.4 0.4 {}
T {10u} -1140 -1410 0 0 0.4 0.4 {}
T {100u} -730 -1410 0 0 0.4 0.4 {}
N -1410 -470 -1410 -450 {
lab=vd11}
N -1410 -450 -1320 -450 {
lab=vd11}
N -1260 -450 -1180 -450 {
lab=vout1p}
N -1180 -470 -1180 -450 {
lab=vout1p}
N -1410 -570 -1410 -530 {
lab=vdd}
N -1410 -570 -1180 -570 {
lab=vdd}
N -1180 -570 -1180 -530 {
lab=vdd}
N -900 -570 -900 -520 {
lab=vdd}
N -900 -570 -670 -570 {
lab=vdd}
N -670 -570 -670 -520 {
lab=vdd}
N -670 -460 -670 -440 {
lab=vd12}
N -750 -440 -670 -440 {
lab=vd12}
N -900 -440 -810 -440 {
lab=vout1n}
N -900 -460 -900 -440 {
lab=vout1n}
N -1300 -630 -1300 -570 {
lab=vdd}
N -1300 -630 -770 -630 {
lab=vdd}
N -770 -630 -770 -570 {
lab=vdd}
N -1410 -450 -1410 -190 {
lab=vd11}
N -1180 -450 -1180 -300 {
lab=vout1p}
N -1410 -270 -1220 -270 {
lab=vd11}
N -900 -440 -900 -300 {
lab=vout1n}
N -670 -440 -670 -210 {
lab=vd12}
N -1180 -240 -1180 -190 {
lab=vs12}
N -1180 -180 -1050 -180 {
lab=vs12}
N -1180 -190 -1180 -180 {
lab=vs12}
N -1050 -180 -900 -180 {
lab=vs12}
N -900 -240 -900 -180 {
lab=vs12}
N -1410 -130 -1410 20 {
lab=vs11}
N -1410 30 -1050 30 {
lab=vs11}
N -1410 20 -1410 30 {
lab=vs11}
N -1050 30 -670 30 {
lab=vs11}
N -670 -150 -670 30 {
lab=vs11}
N -860 -270 -670 -270 {
lab=vd12}
N -1570 -160 -1450 -160 {
lab=vinp}
N -630 -180 -510 -180 {
lab=vinn}
N -1520 -730 -1120 -730 {
lab=vdd}
N -1120 -730 -1120 -630 {
lab=vdd}
N -1200 60 -1090 60 {
lab=vo}
N -1050 90 -1050 120 {
lab=GND}
N -1050 -120 -1050 -90 {
lab=GND}
N -1180 -150 -1090 -150 {
lab=vo2}
N -1050 60 -980 60 {
lab=GND}
N -720 -180 -670 -180 {
lab=GND}
N -1410 -160 -1340 -160 {
lab=GND}
N -1050 -150 -990 -150 {
lab=GND}
N -990 -150 -990 -110 {
lab=GND}
N -1050 -110 -990 -110 {
lab=GND}
N -950 -270 -900 -270 {
lab=GND}
N -1180 -270 -1150 -270 {
lab=GND}
N -1440 -500 -1430 -500 {
lab=GND}
N -1290 -480 -1250 -480 {
lab=GND}
N -1290 -480 -1290 -470 {
lab=GND}
N -1250 -500 -1250 -480 {
lab=GND}
N -1250 -500 -1200 -500 {
lab=GND}
N -940 -490 -920 -490 {
lab=GND}
N -780 -470 -780 -460 {
lab=GND}
N -780 -470 -730 -470 {
lab=GND}
N -730 -490 -730 -470 {
lab=GND}
N -730 -490 -690 -490 {
lab=GND}
N -980 60 -980 110 {
lab=GND}
N -1050 110 -980 110 {
lab=GND}
N -1050 -270 -950 -270 {
lab=GND}
N -1050 -270 -1050 -230 {
lab=GND}
N -1150 -270 -1050 -270 {
lab=GND}
N -1690 -160 -1570 -160 {
lab=vinp}
N -1740 -80 -1740 -60 {
lab=GND}
N -1740 -160 -1740 -140 {
lab=vinp}
N -1740 -160 -1690 -160 {
lab=vinp}
N -500 -80 -500 -60 {
lab=GND}
N -500 -160 -500 -140 {
lab=vinn}
N -500 -180 -500 -160 {
lab=vinn}
N -510 -180 -500 -180 {
lab=vinn}
N -1830 0 -1830 50 {
lab=GND}
N -1830 -100 -1830 -60 {
lab=vc}
N -2020 10 -2020 30 {
lab=GND}
N -2020 -70 -2020 -50 {
lab=vref}
N -1110 -1620 -1110 -1590 { lab=#net1}
N -1020 -1590 -930 -1590 { lab=#net1}
N -930 -1620 -930 -1590 { lab=#net1}
N -1020 -1510 -1000 -1510 { lab=GND}
N -1000 -1510 -1000 -1450 { lab=GND}
N -1020 -1590 -1020 -1540 { lab=#net1}
N -1000 -1650 -930 -1650 { lab=GND}
N -1000 -1650 -1000 -1510 { lab=GND}
N -790 -1510 -750 -1510 { lab=vbias2}
N -790 -1560 -790 -1510 { lab=vbias2}
N -1090 -1560 -790 -1560 { lab=vbias2}
N -1370 -1560 -1370 -1540 { lab=vbias2}
N -1330 -1510 -1290 -1510 { lab=vbias2}
N -1290 -1560 -1290 -1510 { lab=vbias2}
N -1090 -1510 -1060 -1510 { lab=vbias2}
N -1090 -1560 -1090 -1510 { lab=vbias2}
N -1370 -1480 -1370 -1450 { lab=GND}
N -1390 -1510 -1370 -1510 { lab=GND}
N -1390 -1510 -1390 -1450 { lab=GND}
N -1020 -1480 -1020 -1450 { lab=GND}
N -1110 -1760 -1110 -1680 { lab=#net2}
N -1070 -1790 -970 -1790 { lab=#net2}
N -930 -1730 -930 -1680 { lab=#net3}
N -930 -1790 -910 -1790 { lab=vdd}
N -910 -1850 -910 -1790 { lab=vdd}
N -930 -1850 -910 -1850 { lab=vdd}
N -1130 -1850 -1130 -1790 { lab=vdd}
N -1130 -1790 -1110 -1790 { lab=vdd}
N -1110 -1850 -1110 -1820 { lab=vdd}
N -930 -1850 -930 -1820 { lab=vdd}
N -710 -1850 -710 -1760 { lab=vdd}
N -910 -1850 -710 -1850 { lab=vdd}
N -710 -1700 -710 -1540 { lab=vo}
N -710 -1730 -690 -1730 { lab=vdd}
N -690 -1850 -690 -1730 { lab=vdd}
N -710 -1850 -690 -1850 { lab=vdd}
N -710 -1510 -690 -1510 { lab=GND}
N -690 -1510 -690 -1450 { lab=GND}
N -710 -1480 -710 -1450 { lab=GND}
N -930 -1730 -750 -1730 { lab=#net3}
N -1020 -1450 -1000 -1450 { lab=GND}
N -1110 -1590 -1020 -1590 { lab=#net1}
N -1110 -1650 -1000 -1650 { lab=GND}
N -1370 -1560 -1290 -1560 { lab=vbias2}
N -1290 -1560 -1090 -1560 { lab=vbias2}
N -1390 -1450 -1370 -1450 { lab=GND}
N -1370 -1450 -1020 -1450 { lab=GND}
N -1130 -1850 -1110 -1850 { lab=vdd}
N -1110 -1850 -930 -1850 { lab=vdd}
N -710 -1450 -690 -1450 { lab=GND}
N -1000 -1450 -710 -1450 { lab=GND}
N -930 -1760 -930 -1730 { lab=#net3}
N -1470 -1450 -1390 -1450 { lab=GND}
N -1470 -1850 -1130 -1850 { lab=vdd}
N -1170 -1650 -1150 -1650 { lab=vref}
N -1020 -1790 -1020 -1730 { lab=#net2}
N -1110 -1730 -1020 -1730 { lab=#net2}
N -890 -1650 -870 -1650 { lab=vcm}
N -710 -1650 -650 -1650 { lab=vo}
N -1470 -1610 -1370 -1610 {
lab=vbias2}
N -1370 -1610 -1370 -1560 {
lab=vbias2}
N -1470 -1850 -1470 -1820 {
lab=vdd}
N -1470 -1760 -1470 -1740 {
lab=GND}
N -1470 -1490 -1470 -1450 {
lab=GND}
N -1470 -1610 -1470 -1550 {
lab=vbias2}
N -1110 -1140 -1110 -1110 { lab=#net4}
N -1020 -1110 -930 -1110 { lab=#net4}
N -930 -1140 -930 -1110 { lab=#net4}
N -1020 -1030 -1000 -1030 { lab=GND}
N -1000 -1030 -1000 -970 { lab=GND}
N -1020 -1110 -1020 -1060 { lab=#net4}
N -1000 -1170 -930 -1170 { lab=GND}
N -1000 -1170 -1000 -1030 { lab=GND}
N -790 -1030 -750 -1030 { lab=vbias2}
N -790 -1080 -790 -1030 { lab=vbias2}
N -1090 -1080 -790 -1080 { lab=vbias2}
N -1090 -1030 -1060 -1030 { lab=vbias2}
N -1090 -1080 -1090 -1030 { lab=vbias2}
N -1020 -1000 -1020 -970 { lab=GND}
N -1110 -1280 -1110 -1200 { lab=#net5}
N -1070 -1310 -970 -1310 { lab=#net5}
N -930 -1250 -930 -1200 { lab=#net6}
N -930 -1310 -910 -1310 { lab=vdd}
N -910 -1370 -910 -1310 { lab=vdd}
N -930 -1370 -910 -1370 { lab=vdd}
N -1130 -1370 -1130 -1310 { lab=vdd}
N -1130 -1310 -1110 -1310 { lab=vdd}
N -1110 -1370 -1110 -1340 { lab=vdd}
N -930 -1370 -930 -1340 { lab=vdd}
N -710 -1370 -710 -1280 { lab=vdd}
N -910 -1370 -710 -1370 { lab=vdd}
N -710 -1220 -710 -1060 { lab=vo2}
N -710 -1250 -690 -1250 { lab=vdd}
N -690 -1370 -690 -1250 { lab=vdd}
N -710 -1370 -690 -1370 { lab=vdd}
N -710 -1030 -690 -1030 { lab=GND}
N -690 -1030 -690 -970 { lab=GND}
N -710 -1000 -710 -970 { lab=GND}
N -930 -1250 -750 -1250 { lab=#net6}
N -1020 -970 -1000 -970 { lab=GND}
N -1110 -1110 -1020 -1110 { lab=#net4}
N -1110 -1170 -1000 -1170 { lab=GND}
N -1290 -1080 -1090 -1080 { lab=vbias2}
N -1370 -970 -1020 -970 { lab=GND}
N -1130 -1370 -1110 -1370 { lab=vdd}
N -1110 -1370 -930 -1370 { lab=vdd}
N -710 -970 -690 -970 { lab=GND}
N -1000 -970 -710 -970 { lab=GND}
N -930 -1280 -930 -1250 { lab=#net6}
N -1470 -1370 -1130 -1370 { lab=vdd}
N -1170 -1170 -1150 -1170 { lab=vref}
N -1020 -1310 -1020 -1250 { lab=#net5}
N -1110 -1250 -1020 -1250 { lab=#net5}
N -890 -1170 -870 -1170 { lab=vcm2}
N -710 -1170 -650 -1170 { lab=vo2}
N -810 -1730 -810 -1710 {
lab=#net3}
N -810 -1650 -760 -1650 {
lab=#net7}
N -760 -1650 -760 -1630 {
lab=#net7}
N -760 -1570 -710 -1570 {
lab=vo}
N -810 -1250 -810 -1220 {
lab=#net6}
N -810 -1160 -760 -1160 {
lab=#net8}
N -760 -1160 -760 -1150 {
lab=#net8}
N -760 -1090 -710 -1090 {
lab=vo2}
N -1830 -1350 -1830 -1310 {
lab=GND}
N -1830 -1350 -1720 -1350 {
lab=GND}
N -1720 -1350 -1720 -1310 {
lab=GND}
N -1900 -1290 -1860 -1290 {
lab=vd11}
N -1800 -1290 -1750 -1290 {
lab=vcm}
N -1690 -1290 -1590 -1290 {
lab=vd12}
N -1880 -1350 -1830 -1350 {
lab=GND}
N -1880 -1350 -1880 -1340 {
lab=GND}
N -1840 -1120 -1840 -1080 {
lab=GND}
N -1840 -1120 -1730 -1120 {
lab=GND}
N -1730 -1120 -1730 -1080 {
lab=GND}
N -1910 -1060 -1870 -1060 {
lab=vout1p}
N -1810 -1060 -1760 -1060 {
lab=vcm2}
N -1700 -1060 -1600 -1060 {
lab=vout1n}
N -1890 -1120 -1840 -1120 {
lab=GND}
N -1890 -1120 -1890 -1110 {
lab=GND}
N -830 -1680 -830 -1670 {
lab=GND}
N -830 -1190 -830 -1180 {
lab=GND}
N -2400 10 -2340 10 {
lab=vgs9}
N -2400 -50 -2400 10 {
lab=vgs9}
N -2400 -50 -2300 -50 {
lab=vgs9}
N -2300 -50 -2300 -20 {
lab=vgs9}
N -2300 40 -2300 80 {
lab=GND}
N -2300 -80 -2300 -50 {
lab=vgs9}
N -2300 -180 -2300 -140 {
lab=vdd}
N -2300 -190 -2300 -180 {
lab=vdd}
N -2300 10 -2230 10 {
lab=GND}
N -2300 60 -2230 60 {
lab=GND}
N -2230 10 -2230 60 {
lab=GND}
N -2640 30 -2580 30 {
lab=vgs8}
N -2640 -30 -2640 30 {
lab=vgs8}
N -2640 -30 -2540 -30 {
lab=vgs8}
N -2540 -30 -2540 0 {
lab=vgs8}
N -2540 60 -2540 100 {
lab=GND}
N -2540 -60 -2540 -30 {
lab=vgs8}
N -2540 -160 -2540 -120 {
lab=vdd}
N -2540 -170 -2540 -160 {
lab=vdd}
N -2540 30 -2470 30 {
lab=GND}
N -2540 80 -2470 80 {
lab=GND}
N -2470 30 -2470 80 {
lab=GND}
N 10 -260 70 -260 {
lab=vout1p}
N 10 -220 70 -220 {
lab=vout1n}
N 120 -390 120 -320 {
lab=vref}
N 160 -390 160 -320 {
lab=vbias2}
N 120 -160 120 -80 {
lab=vdd}
N 160 -160 160 -80 {
lab=GND}
N 240 -260 320 -260 {
lab=vout2p}
N 240 -220 320 -220 {
lab=vout2n}
N 320 -220 370 -220 {
lab=vout2n}
N 370 -220 450 -220 {
lab=vout2n}
N 460 -260 510 -260 {
lab=vout2p}
N 510 -260 590 -260 {
lab=vout2p}
N 320 -260 470 -260 {
lab=vout2p}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1410 -500 0 0 {name=R1
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1180 -500 0 0 {name=R2
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=3}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1290 -450 1 0 {name=R3
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=2}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -900 -490 0 0 {name=R4
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=3}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -670 -490 0 0 {name=R5
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -780 -440 1 0 {name=R6
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=2}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1430 -160 0 0 {name=M1
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1200 -270 0 0 {name=M2
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -880 -270 0 1 {name=M3
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -650 -180 0 1 {name=M4
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1070 -150 0 0 {name=M5
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1070 60 0 0 {name=M6
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -1050 120 0 0 {name=l2 lab=GND}
C {gnd.sym} -1050 -90 0 0 {name=l3 lab=GND}
C {gnd.sym} -1440 -500 0 0 {name=l8 lab=GND}
C {gnd.sym} -1250 -480 0 0 {name=l9 lab=GND}
C {gnd.sym} -940 -490 0 0 {name=l10 lab=GND}
C {gnd.sym} -730 -470 0 0 {name=l11 lab=GND}
C {gnd.sym} -1340 -160 0 0 {name=l12 lab=GND}
C {gnd.sym} -1050 -230 0 0 {name=l13 lab=GND}
C {gnd.sym} -720 -180 0 0 {name=l14 lab=GND}
C {lab_pin.sym} -1410 30 0 0 {name=l15 sig_type=std_logic lab=vs11}
C {lab_pin.sym} -1410 -350 0 0 {name=l16 sig_type=std_logic lab=vd11}
C {lab_pin.sym} -1180 -390 0 0 {name=l17 sig_type=std_logic lab=vout1p}
C {lab_pin.sym} -1180 -200 0 0 {name=l18 sig_type=std_logic lab=vs12}
C {lab_pin.sym} -900 -390 0 0 {name=l25 sig_type=std_logic lab=vout1n}
C {lab_pin.sym} -670 -380 0 0 {name=l103 sig_type=std_logic lab=vd12}
C {gnd.sym} -1740 -60 0 0 {name=l107 lab=GND}
C {gnd.sym} -500 -60 0 0 {name=l5 lab=GND}
C {lab_pin.sym} -1530 -160 0 0 {name=l6 sig_type=std_logic lab=vinp}
C {lab_pin.sym} -550 -180 0 0 {name=l108 sig_type=std_logic lab=vinn}
C {vsource.sym} -1830 -30 0 0 {name=V9 value=0
}
C {gnd.sym} -1830 50 0 0 {name=l111 lab=GND}
C {lab_pin.sym} -1830 -90 0 0 {name=l112 sig_type=std_logic lab=vc}
C {vsource.sym} -2020 -20 0 0 {name=V11 value="DC 1.25 "}
C {gnd.sym} -2020 30 0 0 {name=l31 lab=GND}
C {lab_pin.sym} -2020 -60 0 0 {name=l32 sig_type=std_logic lab=vref}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1350 -1510 0 1 {name=M9
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1130 -1650 0 0 {name=M46
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -910 -1650 0 1 {name=M47
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1040 -1510 0 0 {name=M48
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -730 -1510 0 0 {name=M49
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -950 -1790 0 0 {name=M50
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -1090 -1790 0 1 {name=M51
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -730 -1730 0 0 {name=M52
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {vsource.sym} -1470 -1790 0 0 {name=V3 value=1.8}
C {gnd.sym} -1470 -1740 0 0 {name=l137 lab=GND}
C {gnd.sym} -1470 -1450 0 0 {name=l140 lab=GND}
C {isource.sym} -1470 -1520 2 0 {name=I0 value=20u}
C {lab_pin.sym} -660 -1650 0 0 {name=l147 sig_type=std_logic lab=vo}
C {lab_pin.sym} -1170 -1650 0 0 {name=l148 sig_type=std_logic lab=vref}
C {lab_pin.sym} -870 -1650 1 1 {name=l149 sig_type=std_logic lab=vcm}
C {sky130_fd_pr/cap_mim_m3_1.sym} -760 -1600 0 0 {name=C3 model=cap_mim_m3_1 W=50 L=50 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1130 -1170 0 0 {name=M54
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -910 -1170 0 1 {name=M55
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1040 -1030 0 0 {name=M56
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -730 -1030 0 0 {name=M57
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -950 -1310 0 0 {name=M58
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -1090 -1310 0 1 {name=M59
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -730 -1250 0 0 {name=M60
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} -660 -1170 0 0 {name=l154 sig_type=std_logic lab=vo2}
C {lab_pin.sym} -1170 -1170 0 0 {name=l155 sig_type=std_logic lab=vref}
C {sky130_fd_pr/cap_mim_m3_1.sym} -760 -1120 0 0 {name=C4 model=cap_mim_m3_1 W=50 L=50 MF=1 spiceprefix=X}
C {lab_pin.sym} -870 -1170 1 1 {name=l156 sig_type=std_logic lab=vcm2}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1830 -1290 1 0 {name=R35
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1720 -1290 1 0 {name=R37
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -1880 -1340 0 0 {name=l157 lab=GND}
C {lab_pin.sym} -1900 -1290 0 0 {name=l158 sig_type=std_logic lab=vd11}
C {lab_pin.sym} -1590 -1290 0 0 {name=l159 sig_type=std_logic lab=vd12}
C {lab_pin.sym} -1770 -1290 1 1 {name=l160 sig_type=std_logic lab=vcm}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1840 -1060 1 0 {name=R38
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1730 -1060 1 0 {name=R39
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -1890 -1110 0 0 {name=l161 lab=GND}
C {lab_pin.sym} -1780 -1060 1 1 {name=l164 sig_type=std_logic lab=vcm2}
C {lab_pin.sym} -1910 -1060 0 0 {name=l141 sig_type=std_logic lab=vout1p}
C {lab_pin.sym} -1610 -1060 0 0 {name=l142 sig_type=std_logic lab=vout1n}
C {lab_pin.sym} -1200 60 0 0 {name=l1 sig_type=std_logic lab=vo}
C {lab_pin.sym} -1180 -150 0 0 {name=l4 sig_type=std_logic lab=vo2}
C {vsource.sym} -1740 -110 0 0 {name=V22 value="DC 1.25 AC 1 SIN(1.25 0.0004 1000MEG)"}
C {vsource.sym} -500 -110 0 0 {name=V4 value="DC 1.25 AC -1 SIN(1.25 -0.0004 1000MEG)"}
C {code.sym} -1890 -650 0 0 {name=TT_MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {code_shown.sym} -2260 -640 0 0 {name=s2 only_toplevel=false value=
"
.ac dec 100 10 30000000000
.options savecurrents
.save all

.control
run
plot db(vout5p-vout5n)
plot i(v3)*1.8
.endc
"}
C {sky130_fd_pr/res_high_po_0p35.sym} -810 -1680 0 0 {name=R33
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -830 -1670 0 0 {name=l233 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} -810 -1190 0 0 {name=R34
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -830 -1180 0 0 {name=l234 lab=GND}
C {lab_pin.sym} -1470 -1850 0 0 {name=l232 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1470 -1370 0 0 {name=l150 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1210 -1560 1 1 {name=l243 sig_type=std_logic lab=vbias2}
C {gnd.sym} -1370 -970 0 0 {name=l152 lab=GND}
C {lab_pin.sym} -1290 -1080 1 1 {name=l244 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} -1520 -730 0 0 {name=l247 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2320 10 0 0 {name=M53
L=0.15
W=0.64
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2300 80 0 0 {name=l251 lab=GND}
C {lab_pin.sym} -2400 -20 0 0 {name=l252 sig_type=std_logic lab=vgs9
}
C {isource.sym} -2300 -110 0 0 {name=I1 value=20u}
C {lab_pin.sym} -2300 -190 0 0 {name=l253 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2560 30 0 0 {name=M61
L=0.15
W=0.64
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2540 100 0 0 {name=l82 lab=GND}
C {lab_pin.sym} -2640 0 0 0 {name=l106 sig_type=std_logic lab=vgs8
}
C {isource.sym} -2540 -90 0 0 {name=I2 value=200u}
C {lab_pin.sym} -2540 -170 0 0 {name=l256 sig_type=std_logic lab=vdd}
C {simulations/VGA_unit.sym} 1480 1180 0 0 {name=Cell1}
C {lab_pin.sym} 10 -260 0 0 {name=l7 sig_type=std_logic lab=vout1p}
C {lab_pin.sym} 10 -220 0 0 {name=l19 sig_type=std_logic lab=vout1n}
C {lab_pin.sym} 120 -90 0 0 {name=l20 sig_type=std_logic lab=vdd}
C {gnd.sym} 160 -80 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 120 -380 0 0 {name=l24 sig_type=std_logic lab=vref}
C {lab_pin.sym} 160 -360 2 1 {name=l27 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} 320 -260 2 0 {name=l30 sig_type=std_logic lab=vout2p}
C {lab_pin.sym} 320 -220 2 0 {name=l33 sig_type=std_logic lab=vout2n}
