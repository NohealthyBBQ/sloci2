v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {10u} -930 -1890 0 0 0.4 0.4 {}
T {10u} -1140 -1890 0 0 0.4 0.4 {}
T {100u} -730 -1890 0 0 0.4 0.4 {}
T {10u} -930 -1410 0 0 0.4 0.4 {}
T {10u} -1140 -1410 0 0 0.4 0.4 {}
T {100u} -730 -1410 0 0 0.4 0.4 {}
T {10u} 560 -1890 0 0 0.4 0.4 {}
T {10u} 350 -1890 0 0 0.4 0.4 {}
T {100u} 760 -1890 0 0 0.4 0.4 {}
T {10u} 560 -1410 0 0 0.4 0.4 {}
T {10u} 350 -1410 0 0 0.4 0.4 {}
T {100u} 760 -1410 0 0 0.4 0.4 {}
T {10u} -2100 1470 0 0 0.4 0.4 {}
T {10u} -2310 1470 0 0 0.4 0.4 {}
T {100u} -1900 1470 0 0 0.4 0.4 {}
T {10u} -2100 1950 0 0 0.4 0.4 {}
T {10u} -2310 1950 0 0 0.4 0.4 {}
T {100u} -1900 1950 0 0 0.4 0.4 {}
T {10u} -690 1490 0 0 0.4 0.4 {}
T {10u} -900 1490 0 0 0.4 0.4 {}
T {100u} -490 1490 0 0 0.4 0.4 {}
T {10u} -690 1970 0 0 0.4 0.4 {}
T {10u} -900 1970 0 0 0.4 0.4 {}
T {100u} -490 1970 0 0 0.4 0.4 {}
T {10u} 690 1460 0 0 0.4 0.4 {}
T {10u} 480 1460 0 0 0.4 0.4 {}
T {100u} 890 1460 0 0 0.4 0.4 {}
T {10u} 690 1940 0 0 0.4 0.4 {}
T {10u} 480 1940 0 0 0.4 0.4 {}
T {100u} 890 1940 0 0 0.4 0.4 {}
N -1410 -470 -1410 -450 {
lab=vd11}
N -1410 -450 -1320 -450 {
lab=vd11}
N -1260 -450 -1180 -450 {
lab=vout1p}
N -1180 -470 -1180 -450 {
lab=vout1p}
N -1410 -570 -1410 -530 {
lab=vdd}
N -1410 -570 -1180 -570 {
lab=vdd}
N -1180 -570 -1180 -530 {
lab=vdd}
N -900 -570 -900 -520 {
lab=vdd}
N -900 -570 -670 -570 {
lab=vdd}
N -670 -570 -670 -520 {
lab=vdd}
N -670 -460 -670 -440 {
lab=vd12}
N -750 -440 -670 -440 {
lab=vd12}
N -900 -440 -810 -440 {
lab=vout1n}
N -900 -460 -900 -440 {
lab=vout1n}
N -1300 -630 -1300 -570 {
lab=vdd}
N -1300 -630 -770 -630 {
lab=vdd}
N -770 -630 -770 -570 {
lab=vdd}
N -1410 -450 -1410 -190 {
lab=vd11}
N -1180 -450 -1180 -300 {
lab=vout1p}
N -1410 -270 -1220 -270 {
lab=vd11}
N -900 -440 -900 -300 {
lab=vout1n}
N -670 -440 -670 -210 {
lab=vd12}
N -1180 -240 -1180 -190 {
lab=vs12}
N -1180 -180 -1050 -180 {
lab=vs12}
N -1180 -190 -1180 -180 {
lab=vs12}
N -1050 -180 -900 -180 {
lab=vs12}
N -900 -240 -900 -180 {
lab=vs12}
N -1410 -130 -1410 20 {
lab=vs11}
N -1410 30 -1050 30 {
lab=vs11}
N -1410 20 -1410 30 {
lab=vs11}
N -1050 30 -670 30 {
lab=vs11}
N -670 -150 -670 30 {
lab=vs11}
N -860 -270 -670 -270 {
lab=vd12}
N -1570 -160 -1450 -160 {
lab=vinp}
N -630 -180 -510 -180 {
lab=vinn}
N -1520 -730 -1120 -730 {
lab=vdd}
N -1120 -730 -1120 -630 {
lab=vdd}
N -1200 60 -1090 60 {
lab=vo}
N -1050 90 -1050 120 {
lab=GND}
N -1050 -120 -1050 -90 {
lab=GND}
N -1180 -150 -1090 -150 {
lab=vo2}
N -1050 60 -980 60 {
lab=GND}
N -720 -180 -670 -180 {
lab=GND}
N -1410 -160 -1340 -160 {
lab=GND}
N -1050 -150 -990 -150 {
lab=GND}
N -990 -150 -990 -110 {
lab=GND}
N -1050 -110 -990 -110 {
lab=GND}
N -950 -270 -900 -270 {
lab=GND}
N -1180 -270 -1150 -270 {
lab=GND}
N -1440 -500 -1430 -500 {
lab=GND}
N -1290 -480 -1250 -480 {
lab=GND}
N -1290 -480 -1290 -470 {
lab=GND}
N -1250 -500 -1250 -480 {
lab=GND}
N -1250 -500 -1200 -500 {
lab=GND}
N -940 -490 -920 -490 {
lab=GND}
N -780 -470 -780 -460 {
lab=GND}
N -780 -470 -730 -470 {
lab=GND}
N -730 -490 -730 -470 {
lab=GND}
N -730 -490 -690 -490 {
lab=GND}
N -980 60 -980 110 {
lab=GND}
N -1050 110 -980 110 {
lab=GND}
N -1050 -270 -950 -270 {
lab=GND}
N -1050 -270 -1050 -230 {
lab=GND}
N -1150 -270 -1050 -270 {
lab=GND}
N -120 -490 -120 -470 {
lab=vd21}
N -120 -470 -30 -470 {
lab=vd21}
N 30 -470 110 -470 {
lab=vout2p}
N 110 -490 110 -470 {
lab=vout2p}
N -120 -590 -120 -550 {
lab=vdd}
N -120 -590 110 -590 {
lab=vdd}
N 110 -590 110 -550 {
lab=vdd}
N 390 -590 390 -540 {
lab=vdd}
N 390 -590 620 -590 {
lab=vdd}
N 620 -590 620 -540 {
lab=vdd}
N 620 -480 620 -460 {
lab=vd22}
N 540 -460 620 -460 {
lab=vd22}
N 390 -460 480 -460 {
lab=vout2n}
N 390 -480 390 -460 {
lab=vout2n}
N -10 -650 -10 -590 {
lab=vdd}
N -10 -650 520 -650 {
lab=vdd}
N 520 -650 520 -590 {
lab=vdd}
N -120 -470 -120 -210 {
lab=vd21}
N 110 -470 110 -320 {
lab=vout2p}
N -120 -290 70 -290 {
lab=vd21}
N 390 -460 390 -320 {
lab=vout2n}
N 620 -460 620 -230 {
lab=vd22}
N 110 -260 110 -210 {
lab=vs22}
N 110 -200 240 -200 {
lab=vs22}
N 110 -210 110 -200 {
lab=vs22}
N 240 -200 390 -200 {
lab=vs22}
N 390 -260 390 -200 {
lab=vs22}
N -120 -150 -120 0 {
lab=vs21}
N -120 10 240 10 {
lab=vs21}
N -120 0 -120 10 {
lab=vs21}
N 240 10 620 10 {
lab=vs21}
N 620 -170 620 10 {
lab=vs21}
N 430 -290 620 -290 {
lab=vd22}
N -280 -180 -160 -180 {
lab=vout1p}
N 660 -200 780 -200 {
lab=vout1n}
N -230 -750 170 -750 {
lab=vdd}
N 170 -750 170 -650 {
lab=vdd}
N 90 40 200 40 {
lab=vo21}
N 240 70 240 100 {
lab=GND}
N 240 -140 240 -110 {
lab=GND}
N 110 -170 200 -170 {
lab=vo22}
N 240 40 310 40 {
lab=GND}
N 570 -200 620 -200 {
lab=GND}
N -120 -180 -50 -180 {
lab=GND}
N 240 -170 300 -170 {
lab=GND}
N 300 -170 300 -130 {
lab=GND}
N 240 -130 300 -130 {
lab=GND}
N 340 -290 390 -290 {
lab=GND}
N 110 -290 140 -290 {
lab=GND}
N -150 -520 -140 -520 {
lab=GND}
N 0 -500 40 -500 {
lab=GND}
N 0 -500 0 -490 {
lab=GND}
N 40 -520 40 -500 {
lab=GND}
N 40 -520 90 -520 {
lab=GND}
N 350 -510 370 -510 {
lab=GND}
N 510 -490 510 -480 {
lab=GND}
N 510 -490 560 -490 {
lab=GND}
N 560 -510 560 -490 {
lab=GND}
N 560 -510 600 -510 {
lab=GND}
N 310 40 310 90 {
lab=GND}
N 240 90 310 90 {
lab=GND}
N 240 -290 340 -290 {
lab=GND}
N 240 -290 240 -250 {
lab=GND}
N 140 -290 240 -290 {
lab=GND}
N -1410 580 -1410 600 {
lab=vd41}
N -1410 600 -1320 600 {
lab=vd41}
N -1260 600 -1180 600 {
lab=vout4p}
N -1180 580 -1180 600 {
lab=vout4p}
N -1410 480 -1410 520 {
lab=vdd}
N -1410 480 -1180 480 {
lab=vdd}
N -1180 480 -1180 520 {
lab=vdd}
N -900 480 -900 530 {
lab=vdd}
N -900 480 -670 480 {
lab=vdd}
N -670 480 -670 530 {
lab=vdd}
N -670 590 -670 610 {
lab=vd42}
N -750 610 -670 610 {
lab=vd42}
N -900 610 -810 610 {
lab=vout4n}
N -900 590 -900 610 {
lab=vout4n}
N -1300 420 -1300 480 {
lab=vdd}
N -1300 420 -770 420 {
lab=vdd}
N -770 420 -770 480 {
lab=vdd}
N -1410 600 -1410 860 {
lab=vd41}
N -1180 600 -1180 750 {
lab=vout4p}
N -1410 780 -1220 780 {
lab=vd41}
N -900 610 -900 750 {
lab=vout4n}
N -670 610 -670 840 {
lab=vd42}
N -1180 810 -1180 860 {
lab=vs42}
N -1180 870 -1050 870 {
lab=vs42}
N -1180 860 -1180 870 {
lab=vs42}
N -1050 870 -900 870 {
lab=vs42}
N -900 810 -900 870 {
lab=vs42}
N -1410 920 -1410 1070 {
lab=vs41}
N -1410 1080 -1050 1080 {
lab=vs41}
N -1410 1070 -1410 1080 {
lab=vs41}
N -1050 1080 -670 1080 {
lab=vs41}
N -670 900 -670 1080 {
lab=vs41}
N -860 780 -670 780 {
lab=vd42}
N -1570 890 -1450 890 {
lab=vout3p}
N -630 870 -510 870 {
lab=vout3n}
N -1520 320 -1120 320 {
lab=vdd}
N -1120 320 -1120 420 {
lab=vdd}
N -1200 1110 -1090 1110 {
lab=vo41}
N -1050 1140 -1050 1170 {
lab=GND}
N -1050 930 -1050 960 {
lab=GND}
N -1180 900 -1090 900 {
lab=vo42}
N -1050 1110 -980 1110 {
lab=GND}
N -720 870 -670 870 {
lab=GND}
N -1410 890 -1340 890 {
lab=GND}
N -1050 900 -990 900 {
lab=GND}
N -990 900 -990 940 {
lab=GND}
N -1050 940 -990 940 {
lab=GND}
N -950 780 -900 780 {
lab=GND}
N -1180 780 -1150 780 {
lab=GND}
N -1440 550 -1430 550 {
lab=GND}
N -1290 570 -1250 570 {
lab=GND}
N -1290 570 -1290 580 {
lab=GND}
N -1250 550 -1250 570 {
lab=GND}
N -1250 550 -1200 550 {
lab=GND}
N -940 560 -920 560 {
lab=GND}
N -780 580 -780 590 {
lab=GND}
N -780 580 -730 580 {
lab=GND}
N -730 560 -730 580 {
lab=GND}
N -730 560 -690 560 {
lab=GND}
N -980 1110 -980 1160 {
lab=GND}
N -1050 1160 -980 1160 {
lab=GND}
N -1050 780 -950 780 {
lab=GND}
N -1050 780 -1050 820 {
lab=GND}
N -1150 780 -1050 780 {
lab=GND}
N -2580 590 -2580 610 {
lab=vd31}
N -2580 610 -2490 610 {
lab=vd31}
N -2430 610 -2350 610 {
lab=vout3p}
N -2350 590 -2350 610 {
lab=vout3p}
N -2580 490 -2580 530 {
lab=vdd}
N -2580 490 -2350 490 {
lab=vdd}
N -2350 490 -2350 530 {
lab=vdd}
N -2070 490 -2070 540 {
lab=vdd}
N -2070 490 -1840 490 {
lab=vdd}
N -1840 490 -1840 540 {
lab=vdd}
N -1840 600 -1840 620 {
lab=vd32}
N -1920 620 -1840 620 {
lab=vd32}
N -2070 620 -1980 620 {
lab=vout3n}
N -2070 600 -2070 620 {
lab=vout3n}
N -2470 430 -2470 490 {
lab=vdd}
N -2470 430 -1940 430 {
lab=vdd}
N -1940 430 -1940 490 {
lab=vdd}
N -2580 610 -2580 870 {
lab=vd31}
N -2350 610 -2350 760 {
lab=vout3p}
N -2580 790 -2390 790 {
lab=vd31}
N -2070 620 -2070 760 {
lab=vout3n}
N -1840 620 -1840 850 {
lab=vd32}
N -2350 820 -2350 870 {
lab=vs32}
N -2350 880 -2220 880 {
lab=vs32}
N -2350 870 -2350 880 {
lab=vs32}
N -2220 880 -2070 880 {
lab=vs32}
N -2070 820 -2070 880 {
lab=vs32}
N -2580 930 -2580 1080 {
lab=vs31}
N -2580 1090 -2220 1090 {
lab=vs31}
N -2580 1080 -2580 1090 {
lab=vs31}
N -2220 1090 -1840 1090 {
lab=vs31}
N -1840 910 -1840 1090 {
lab=vs31}
N -2030 790 -1840 790 {
lab=vd32}
N -2740 900 -2620 900 {
lab=vout2p}
N -1800 880 -1680 880 {
lab=vout2n}
N -2690 330 -2290 330 {
lab=vdd}
N -2290 330 -2290 430 {
lab=vdd}
N -2370 1120 -2260 1120 {
lab=vo31}
N -2220 1150 -2220 1180 {
lab=GND}
N -2220 940 -2220 970 {
lab=GND}
N -2350 910 -2260 910 {
lab=vo32}
N -2220 1120 -2150 1120 {
lab=GND}
N -1890 880 -1840 880 {
lab=GND}
N -2580 900 -2510 900 {
lab=GND}
N -2220 910 -2160 910 {
lab=GND}
N -2160 910 -2160 950 {
lab=GND}
N -2220 950 -2160 950 {
lab=GND}
N -2120 790 -2070 790 {
lab=GND}
N -2350 790 -2320 790 {
lab=GND}
N -2610 560 -2600 560 {
lab=GND}
N -2460 580 -2420 580 {
lab=GND}
N -2460 580 -2460 590 {
lab=GND}
N -2420 560 -2420 580 {
lab=GND}
N -2420 560 -2370 560 {
lab=GND}
N -2110 570 -2090 570 {
lab=GND}
N -1950 590 -1950 600 {
lab=GND}
N -1950 590 -1900 590 {
lab=GND}
N -1900 570 -1900 590 {
lab=GND}
N -1900 570 -1860 570 {
lab=GND}
N -2150 1120 -2150 1170 {
lab=GND}
N -2220 1170 -2150 1170 {
lab=GND}
N -2220 790 -2120 790 {
lab=GND}
N -2220 790 -2220 830 {
lab=GND}
N -2320 790 -2220 790 {
lab=GND}
N -150 600 -150 620 {
lab=vd51}
N -150 620 -60 620 {
lab=vd51}
N 0 620 80 620 {
lab=vout5p}
N 80 600 80 620 {
lab=vout5p}
N -150 500 -150 540 {
lab=vdd}
N -150 500 80 500 {
lab=vdd}
N 80 500 80 540 {
lab=vdd}
N 360 500 360 550 {
lab=vdd}
N 360 500 590 500 {
lab=vdd}
N 590 500 590 550 {
lab=vdd}
N 590 610 590 630 {
lab=vd52}
N 510 630 590 630 {
lab=vd52}
N 360 630 450 630 {
lab=vout5n}
N 360 610 360 630 {
lab=vout5n}
N -40 440 -40 500 {
lab=vdd}
N -40 440 490 440 {
lab=vdd}
N 490 440 490 500 {
lab=vdd}
N -150 620 -150 880 {
lab=vd51}
N 80 620 80 770 {
lab=vout5p}
N -150 800 40 800 {
lab=vd51}
N 360 630 360 770 {
lab=vout5n}
N 590 630 590 860 {
lab=vd52}
N 80 830 80 880 {
lab=vs52}
N 80 890 210 890 {
lab=vs52}
N 80 880 80 890 {
lab=vs52}
N 210 890 360 890 {
lab=vs52}
N 360 830 360 890 {
lab=vs52}
N -150 940 -150 1090 {
lab=vs51}
N -150 1100 210 1100 {
lab=vs51}
N -150 1090 -150 1100 {
lab=vs51}
N 210 1100 590 1100 {
lab=vs51}
N 590 920 590 1100 {
lab=vs51}
N 400 800 590 800 {
lab=vd52}
N -310 910 -190 910 {
lab=vout4p}
N 630 890 750 890 {
lab=vout4n}
N -260 340 140 340 {
lab=vdd}
N 140 340 140 440 {
lab=vdd}
N 60 1130 170 1130 {
lab=vo51}
N 210 1160 210 1190 {
lab=GND}
N 210 950 210 980 {
lab=GND}
N 80 920 170 920 {
lab=vo52}
N 210 1130 280 1130 {
lab=GND}
N 540 890 590 890 {
lab=GND}
N -150 910 -80 910 {
lab=GND}
N 210 920 270 920 {
lab=GND}
N 270 920 270 960 {
lab=GND}
N 210 960 270 960 {
lab=GND}
N 310 800 360 800 {
lab=GND}
N 80 800 110 800 {
lab=GND}
N -180 570 -170 570 {
lab=GND}
N -30 590 10 590 {
lab=GND}
N -30 590 -30 600 {
lab=GND}
N 10 570 10 590 {
lab=GND}
N 10 570 60 570 {
lab=GND}
N 320 580 340 580 {
lab=GND}
N 480 600 480 610 {
lab=GND}
N 480 600 530 600 {
lab=GND}
N 530 580 530 600 {
lab=GND}
N 530 580 570 580 {
lab=GND}
N 280 1130 280 1180 {
lab=GND}
N 210 1180 280 1180 {
lab=GND}
N 210 800 310 800 {
lab=GND}
N 210 800 210 840 {
lab=GND}
N 110 800 210 800 {
lab=GND}
N -1690 -160 -1570 -160 {
lab=vinp}
N 1210 620 1210 640 {
lab=vfbn}
N 1950 630 1950 650 {
lab=vfbp}
N 1210 640 1210 900 {
lab=vfbn}
N 1950 650 1950 880 {
lab=vfbp}
N 1210 960 1210 1110 {
lab=vst}
N 1210 1120 1570 1120 {
lab=vst}
N 1210 1110 1210 1120 {
lab=vst}
N 1570 1120 1950 1120 {
lab=vst}
N 1950 940 1950 1120 {
lab=vst}
N 1050 930 1170 930 {
lab=vout5p}
N 1990 910 2110 910 {
lab=vout5n}
N 1420 1150 1530 1150 {
lab=vgs8}
N 1570 1180 1570 1210 {
lab=GND}
N 1570 1150 1640 1150 {
lab=GND}
N 1900 910 1950 910 {
lab=GND}
N 1210 930 1280 930 {
lab=GND}
N 1180 590 1190 590 {
lab=GND}
N 1890 600 1930 600 {
lab=GND}
N 1640 1150 1640 1200 {
lab=GND}
N 1570 1200 1640 1200 {
lab=GND}
N 1100 340 1210 340 {
lab=vdd}
N 1210 340 1210 560 {
lab=vdd}
N 1210 430 1950 430 {
lab=vdd}
N 1950 430 1950 570 {
lab=vdd}
N -1740 -80 -1740 -60 {
lab=GND}
N -1740 -160 -1740 -140 {
lab=vinp}
N -1740 -160 -1690 -160 {
lab=vinp}
N -500 -80 -500 -60 {
lab=GND}
N -500 -160 -500 -140 {
lab=vinn}
N -500 -180 -500 -160 {
lab=vinn}
N -510 -180 -500 -180 {
lab=vinn}
N 1480 30 1480 80 {
lab=vsoc}
N 1480 80 1570 80 {
lab=vsoc}
N 1570 80 1660 80 {
lab=vsoc}
N 1660 30 1660 80 {
lab=vsoc}
N 1570 140 1570 160 {
lab=GND}
N 1570 110 1610 110 {
lab=GND}
N 1610 110 1610 150 {
lab=GND}
N 1570 150 1610 150 {
lab=GND}
N 1480 0 1570 0 {
lab=GND}
N 1570 0 1570 40 {
lab=GND}
N 1570 0 1660 0 {
lab=GND}
N 1390 0 1440 0 {
lab=vin0p}
N 1700 0 1770 0 {
lab=vin0n}
N 1480 -110 1480 -30 {
lab=vd11}
N 1660 -110 1660 -30 {
lab=vd12}
N 1480 110 1530 110 {
lab=vgs9}
N 2550 1190 2550 1230 {
lab=vin0p}
N 2550 1290 2550 1330 {
lab=GND}
N 2550 1070 2550 1130 {
lab=vfbn}
N 2780 1190 2780 1230 {
lab=vin0n}
N 2780 1290 2780 1330 {
lab=GND}
N 2780 1070 2780 1130 {
lab=vfbp}
N -1830 0 -1830 50 {
lab=GND}
N -1830 -100 -1830 -60 {
lab=vc}
N -120 -420 -30 -420 {
lab=vd21}
N 30 -420 110 -420 {
lab=vout2p}
N 0 -380 0 -350 {
lab=vc}
N 390 -430 480 -430 {
lab=vout2n}
N 540 -430 620 -430 {
lab=vd22}
N 510 -390 510 -360 {
lab=vc}
N -150 660 -60 660 {
lab=vd51}
N 0 660 80 660 {
lab=vout5p}
N -30 700 -30 740 {
lab=vc}
N 510 670 590 670 {
lab=vd52}
N 360 670 450 670 {
lab=vout5n}
N 480 710 480 760 {
lab=vc}
N -1410 630 -1320 630 {
lab=vd41}
N -1260 630 -1180 630 {
lab=vout4p}
N -1290 670 -1290 710 {
lab=vc}
N -900 640 -800 640 {
lab=vout4n}
N -740 640 -670 640 {
lab=vd42}
N -770 680 -770 710 {
lab=vc}
N -2580 650 -2490 650 {
lab=vd31}
N -2430 650 -2350 650 {
lab=vout3p}
N -2460 690 -2460 730 {
lab=vc}
N -2070 660 -1980 660 {
lab=vout3n}
N -1920 660 -1840 660 {
lab=vd32}
N -1950 700 -1950 740 {
lab=vc}
N -2020 10 -2020 30 {
lab=GND}
N -2020 -70 -2020 -50 {
lab=vref}
N -1110 -1620 -1110 -1590 { lab=#net1}
N -1020 -1590 -930 -1590 { lab=#net1}
N -930 -1620 -930 -1590 { lab=#net1}
N -1020 -1510 -1000 -1510 { lab=GND}
N -1000 -1510 -1000 -1450 { lab=GND}
N -1020 -1590 -1020 -1540 { lab=#net1}
N -1000 -1650 -930 -1650 { lab=GND}
N -1000 -1650 -1000 -1510 { lab=GND}
N -790 -1510 -750 -1510 { lab=vbias2}
N -790 -1560 -790 -1510 { lab=vbias2}
N -1090 -1560 -790 -1560 { lab=vbias2}
N -1370 -1560 -1370 -1540 { lab=vbias2}
N -1330 -1510 -1290 -1510 { lab=vbias2}
N -1290 -1560 -1290 -1510 { lab=vbias2}
N -1090 -1510 -1060 -1510 { lab=vbias2}
N -1090 -1560 -1090 -1510 { lab=vbias2}
N -1370 -1480 -1370 -1450 { lab=GND}
N -1390 -1510 -1370 -1510 { lab=GND}
N -1390 -1510 -1390 -1450 { lab=GND}
N -1020 -1480 -1020 -1450 { lab=GND}
N -1110 -1760 -1110 -1680 { lab=#net2}
N -1070 -1790 -970 -1790 { lab=#net2}
N -930 -1730 -930 -1680 { lab=#net3}
N -930 -1790 -910 -1790 { lab=vdd}
N -910 -1850 -910 -1790 { lab=vdd}
N -930 -1850 -910 -1850 { lab=vdd}
N -1130 -1850 -1130 -1790 { lab=vdd}
N -1130 -1790 -1110 -1790 { lab=vdd}
N -1110 -1850 -1110 -1820 { lab=vdd}
N -930 -1850 -930 -1820 { lab=vdd}
N -710 -1850 -710 -1760 { lab=vdd}
N -910 -1850 -710 -1850 { lab=vdd}
N -710 -1700 -710 -1540 { lab=vo}
N -710 -1730 -690 -1730 { lab=vdd}
N -690 -1850 -690 -1730 { lab=vdd}
N -710 -1850 -690 -1850 { lab=vdd}
N -710 -1510 -690 -1510 { lab=GND}
N -690 -1510 -690 -1450 { lab=GND}
N -710 -1480 -710 -1450 { lab=GND}
N -930 -1730 -750 -1730 { lab=#net3}
N -1020 -1450 -1000 -1450 { lab=GND}
N -1110 -1590 -1020 -1590 { lab=#net1}
N -1110 -1650 -1000 -1650 { lab=GND}
N -1370 -1560 -1290 -1560 { lab=vbias2}
N -1290 -1560 -1090 -1560 { lab=vbias2}
N -1390 -1450 -1370 -1450 { lab=GND}
N -1370 -1450 -1020 -1450 { lab=GND}
N -1130 -1850 -1110 -1850 { lab=vdd}
N -1110 -1850 -930 -1850 { lab=vdd}
N -710 -1450 -690 -1450 { lab=GND}
N -1000 -1450 -710 -1450 { lab=GND}
N -930 -1760 -930 -1730 { lab=#net3}
N -1470 -1450 -1390 -1450 { lab=GND}
N -1470 -1850 -1130 -1850 { lab=vdd}
N -1170 -1650 -1150 -1650 { lab=vref}
N -1020 -1790 -1020 -1730 { lab=#net2}
N -1110 -1730 -1020 -1730 { lab=#net2}
N -890 -1650 -870 -1650 { lab=vcm}
N -710 -1650 -650 -1650 { lab=vo}
N -1470 -1610 -1370 -1610 {
lab=vbias2}
N -1370 -1610 -1370 -1560 {
lab=vbias2}
N -1470 -1850 -1470 -1820 {
lab=vdd}
N -1470 -1760 -1470 -1740 {
lab=GND}
N -1470 -1490 -1470 -1450 {
lab=GND}
N -1470 -1610 -1470 -1550 {
lab=vbias2}
N -1110 -1140 -1110 -1110 { lab=#net4}
N -1020 -1110 -930 -1110 { lab=#net4}
N -930 -1140 -930 -1110 { lab=#net4}
N -1020 -1030 -1000 -1030 { lab=GND}
N -1000 -1030 -1000 -970 { lab=GND}
N -1020 -1110 -1020 -1060 { lab=#net4}
N -1000 -1170 -930 -1170 { lab=GND}
N -1000 -1170 -1000 -1030 { lab=GND}
N -790 -1030 -750 -1030 { lab=vbias2}
N -790 -1080 -790 -1030 { lab=vbias2}
N -1090 -1080 -790 -1080 { lab=vbias2}
N -1090 -1030 -1060 -1030 { lab=vbias2}
N -1090 -1080 -1090 -1030 { lab=vbias2}
N -1020 -1000 -1020 -970 { lab=GND}
N -1110 -1280 -1110 -1200 { lab=#net5}
N -1070 -1310 -970 -1310 { lab=#net5}
N -930 -1250 -930 -1200 { lab=#net6}
N -930 -1310 -910 -1310 { lab=vdd}
N -910 -1370 -910 -1310 { lab=vdd}
N -930 -1370 -910 -1370 { lab=vdd}
N -1130 -1370 -1130 -1310 { lab=vdd}
N -1130 -1310 -1110 -1310 { lab=vdd}
N -1110 -1370 -1110 -1340 { lab=vdd}
N -930 -1370 -930 -1340 { lab=vdd}
N -710 -1370 -710 -1280 { lab=vdd}
N -910 -1370 -710 -1370 { lab=vdd}
N -710 -1220 -710 -1060 { lab=vo2}
N -710 -1250 -690 -1250 { lab=vdd}
N -690 -1370 -690 -1250 { lab=vdd}
N -710 -1370 -690 -1370 { lab=vdd}
N -710 -1030 -690 -1030 { lab=GND}
N -690 -1030 -690 -970 { lab=GND}
N -710 -1000 -710 -970 { lab=GND}
N -930 -1250 -750 -1250 { lab=#net6}
N -1020 -970 -1000 -970 { lab=GND}
N -1110 -1110 -1020 -1110 { lab=#net4}
N -1110 -1170 -1000 -1170 { lab=GND}
N -1290 -1080 -1090 -1080 { lab=vbias2}
N -1370 -970 -1020 -970 { lab=GND}
N -1130 -1370 -1110 -1370 { lab=vdd}
N -1110 -1370 -930 -1370 { lab=vdd}
N -710 -970 -690 -970 { lab=GND}
N -1000 -970 -710 -970 { lab=GND}
N -930 -1280 -930 -1250 { lab=#net6}
N -1470 -1370 -1130 -1370 { lab=vdd}
N -1170 -1170 -1150 -1170 { lab=vref}
N -1020 -1310 -1020 -1250 { lab=#net5}
N -1110 -1250 -1020 -1250 { lab=#net5}
N -890 -1170 -870 -1170 { lab=vcm2}
N -710 -1170 -650 -1170 { lab=vo2}
N -810 -1730 -810 -1710 {
lab=#net3}
N -810 -1650 -760 -1650 {
lab=#net7}
N -760 -1650 -760 -1630 {
lab=#net7}
N -760 -1570 -710 -1570 {
lab=vo}
N -810 -1250 -810 -1220 {
lab=#net6}
N -810 -1160 -760 -1160 {
lab=#net8}
N -760 -1160 -760 -1150 {
lab=#net8}
N -760 -1090 -710 -1090 {
lab=vo2}
N -1830 -1350 -1830 -1310 {
lab=GND}
N -1830 -1350 -1720 -1350 {
lab=GND}
N -1720 -1350 -1720 -1310 {
lab=GND}
N -1900 -1290 -1860 -1290 {
lab=vd11}
N -1800 -1290 -1750 -1290 {
lab=vcm}
N -1690 -1290 -1590 -1290 {
lab=vd12}
N -1880 -1350 -1830 -1350 {
lab=GND}
N -1880 -1350 -1880 -1340 {
lab=GND}
N -1840 -1120 -1840 -1080 {
lab=GND}
N -1840 -1120 -1730 -1120 {
lab=GND}
N -1730 -1120 -1730 -1080 {
lab=GND}
N -1910 -1060 -1870 -1060 {
lab=vout1p}
N -1810 -1060 -1760 -1060 {
lab=vcm2}
N -1700 -1060 -1600 -1060 {
lab=vout1n}
N -1890 -1120 -1840 -1120 {
lab=GND}
N -1890 -1120 -1890 -1110 {
lab=GND}
N 380 -1620 380 -1590 { lab=#net9}
N 470 -1590 560 -1590 { lab=#net9}
N 560 -1620 560 -1590 { lab=#net9}
N 470 -1510 490 -1510 { lab=GND}
N 490 -1510 490 -1450 { lab=GND}
N 470 -1590 470 -1540 { lab=#net9}
N 490 -1650 560 -1650 { lab=GND}
N 490 -1650 490 -1510 { lab=GND}
N 700 -1510 740 -1510 { lab=vbias2}
N 700 -1560 700 -1510 { lab=vbias2}
N 400 -1560 700 -1560 { lab=vbias2}
N 400 -1510 430 -1510 { lab=vbias2}
N 400 -1560 400 -1510 { lab=vbias2}
N 470 -1480 470 -1450 { lab=GND}
N 380 -1760 380 -1680 { lab=#net10}
N 420 -1790 520 -1790 { lab=#net10}
N 560 -1730 560 -1680 { lab=#net11}
N 560 -1790 580 -1790 { lab=vdd}
N 580 -1850 580 -1790 { lab=vdd}
N 560 -1850 580 -1850 { lab=vdd}
N 360 -1850 360 -1790 { lab=vdd}
N 360 -1790 380 -1790 { lab=vdd}
N 380 -1850 380 -1820 { lab=vdd}
N 560 -1850 560 -1820 { lab=vdd}
N 780 -1850 780 -1760 { lab=vdd}
N 580 -1850 780 -1850 { lab=vdd}
N 780 -1700 780 -1540 { lab=vo21}
N 780 -1730 800 -1730 { lab=vdd}
N 800 -1850 800 -1730 { lab=vdd}
N 780 -1850 800 -1850 { lab=vdd}
N 780 -1510 800 -1510 { lab=GND}
N 800 -1510 800 -1450 { lab=GND}
N 780 -1480 780 -1450 { lab=GND}
N 560 -1730 740 -1730 { lab=#net11}
N 470 -1450 490 -1450 { lab=GND}
N 380 -1590 470 -1590 { lab=#net9}
N 380 -1650 490 -1650 { lab=GND}
N 200 -1560 400 -1560 { lab=vbias2}
N 100 -1450 120 -1450 { lab=GND}
N 120 -1450 470 -1450 { lab=GND}
N 360 -1850 380 -1850 { lab=vdd}
N 380 -1850 560 -1850 { lab=vdd}
N 780 -1450 800 -1450 { lab=GND}
N 490 -1450 780 -1450 { lab=GND}
N 560 -1760 560 -1730 { lab=#net11}
N 20 -1450 100 -1450 { lab=GND}
N 20 -1850 360 -1850 { lab=vdd}
N 320 -1650 340 -1650 { lab=vref}
N 470 -1790 470 -1730 { lab=#net10}
N 380 -1730 470 -1730 { lab=#net10}
N 600 -1650 620 -1650 { lab=vcm21}
N 780 -1650 840 -1650 { lab=vo21}
N 380 -1140 380 -1110 { lab=#net12}
N 470 -1110 560 -1110 { lab=#net12}
N 560 -1140 560 -1110 { lab=#net12}
N 470 -1030 490 -1030 { lab=GND}
N 490 -1030 490 -970 { lab=GND}
N 470 -1110 470 -1060 { lab=#net12}
N 490 -1170 560 -1170 { lab=GND}
N 490 -1170 490 -1030 { lab=GND}
N 700 -1030 740 -1030 { lab=vbias2}
N 700 -1080 700 -1030 { lab=vbias2}
N 400 -1080 700 -1080 { lab=vbias2}
N 400 -1030 430 -1030 { lab=vbias2}
N 400 -1080 400 -1030 { lab=vbias2}
N 470 -1000 470 -970 { lab=GND}
N 380 -1280 380 -1200 { lab=#net13}
N 420 -1310 520 -1310 { lab=#net13}
N 560 -1250 560 -1200 { lab=#net14}
N 560 -1310 580 -1310 { lab=vdd}
N 580 -1370 580 -1310 { lab=vdd}
N 560 -1370 580 -1370 { lab=vdd}
N 360 -1370 360 -1310 { lab=vdd}
N 360 -1310 380 -1310 { lab=vdd}
N 380 -1370 380 -1340 { lab=vdd}
N 560 -1370 560 -1340 { lab=vdd}
N 780 -1370 780 -1280 { lab=vdd}
N 580 -1370 780 -1370 { lab=vdd}
N 780 -1220 780 -1060 { lab=vo22}
N 780 -1250 800 -1250 { lab=vdd}
N 800 -1370 800 -1250 { lab=vdd}
N 780 -1370 800 -1370 { lab=vdd}
N 780 -1030 800 -1030 { lab=GND}
N 800 -1030 800 -970 { lab=GND}
N 780 -1000 780 -970 { lab=GND}
N 560 -1250 740 -1250 { lab=#net14}
N 470 -970 490 -970 { lab=GND}
N 380 -1110 470 -1110 { lab=#net12}
N 380 -1170 490 -1170 { lab=GND}
N 200 -1080 400 -1080 { lab=vbias2}
N 100 -970 120 -970 { lab=GND}
N 120 -970 470 -970 { lab=GND}
N 360 -1370 380 -1370 { lab=vdd}
N 380 -1370 560 -1370 { lab=vdd}
N 780 -970 800 -970 { lab=GND}
N 490 -970 780 -970 { lab=GND}
N 560 -1280 560 -1250 { lab=#net14}
N 20 -970 100 -970 { lab=GND}
N 20 -1370 360 -1370 { lab=vdd}
N 320 -1170 340 -1170 { lab=vref}
N 470 -1310 470 -1250 { lab=#net13}
N 380 -1250 470 -1250 { lab=#net13}
N 600 -1170 620 -1170 { lab=vcm22}
N 780 -1170 840 -1170 { lab=vo22}
N 680 -1730 680 -1710 {
lab=#net11}
N 680 -1650 730 -1650 {
lab=#net15}
N 730 -1650 730 -1630 {
lab=#net15}
N 730 -1570 780 -1570 {
lab=vo21}
N 680 -1250 680 -1220 {
lab=#net14}
N 680 -1160 730 -1160 {
lab=#net16}
N 730 -1160 730 -1150 {
lab=#net16}
N 730 -1090 780 -1090 {
lab=vo22}
N -340 -1350 -340 -1310 {
lab=GND}
N -340 -1350 -230 -1350 {
lab=GND}
N -230 -1350 -230 -1310 {
lab=GND}
N -410 -1290 -370 -1290 {
lab=vd21}
N -310 -1290 -260 -1290 {
lab=vcm21}
N -200 -1290 -100 -1290 {
lab=vd22}
N -390 -1350 -340 -1350 {
lab=GND}
N -390 -1350 -390 -1340 {
lab=GND}
N -350 -1120 -350 -1080 {
lab=GND}
N -350 -1120 -240 -1120 {
lab=GND}
N -240 -1120 -240 -1080 {
lab=GND}
N -420 -1060 -380 -1060 {
lab=vout2p}
N -320 -1060 -270 -1060 {
lab=vcm22}
N -210 -1060 -110 -1060 {
lab=vout2n}
N -400 -1120 -350 -1120 {
lab=GND}
N -400 -1120 -400 -1110 {
lab=GND}
N -2280 1740 -2280 1770 { lab=#net17}
N -2190 1770 -2100 1770 { lab=#net17}
N -2100 1740 -2100 1770 { lab=#net17}
N -2190 1850 -2170 1850 { lab=GND}
N -2170 1850 -2170 1910 { lab=GND}
N -2190 1770 -2190 1820 { lab=#net17}
N -2170 1710 -2100 1710 { lab=GND}
N -2170 1710 -2170 1850 { lab=GND}
N -1960 1850 -1920 1850 { lab=vbias2}
N -1960 1800 -1960 1850 { lab=vbias2}
N -2260 1800 -1960 1800 { lab=vbias2}
N -2260 1850 -2230 1850 { lab=vbias2}
N -2260 1800 -2260 1850 { lab=vbias2}
N -2190 1880 -2190 1910 { lab=GND}
N -2280 1600 -2280 1680 { lab=#net18}
N -2240 1570 -2140 1570 { lab=#net18}
N -2100 1630 -2100 1680 { lab=#net19}
N -2100 1570 -2080 1570 { lab=vdd}
N -2080 1510 -2080 1570 { lab=vdd}
N -2100 1510 -2080 1510 { lab=vdd}
N -2300 1510 -2300 1570 { lab=vdd}
N -2300 1570 -2280 1570 { lab=vdd}
N -2280 1510 -2280 1540 { lab=vdd}
N -2100 1510 -2100 1540 { lab=vdd}
N -1880 1510 -1880 1600 { lab=vdd}
N -2080 1510 -1880 1510 { lab=vdd}
N -1880 1660 -1880 1820 { lab=vo31}
N -1880 1630 -1860 1630 { lab=vdd}
N -1860 1510 -1860 1630 { lab=vdd}
N -1880 1510 -1860 1510 { lab=vdd}
N -1880 1850 -1860 1850 { lab=GND}
N -1860 1850 -1860 1910 { lab=GND}
N -1880 1880 -1880 1910 { lab=GND}
N -2100 1630 -1920 1630 { lab=#net19}
N -2190 1910 -2170 1910 { lab=GND}
N -2280 1770 -2190 1770 { lab=#net17}
N -2280 1710 -2170 1710 { lab=GND}
N -2460 1800 -2260 1800 { lab=vbias2}
N -2560 1910 -2540 1910 { lab=GND}
N -2540 1910 -2190 1910 { lab=GND}
N -2300 1510 -2280 1510 { lab=vdd}
N -2280 1510 -2100 1510 { lab=vdd}
N -1880 1910 -1860 1910 { lab=GND}
N -2170 1910 -1880 1910 { lab=GND}
N -2100 1600 -2100 1630 { lab=#net19}
N -2640 1910 -2560 1910 { lab=GND}
N -2640 1510 -2300 1510 { lab=vdd}
N -2340 1710 -2320 1710 { lab=vref}
N -2190 1570 -2190 1630 { lab=#net18}
N -2280 1630 -2190 1630 { lab=#net18}
N -2060 1710 -2040 1710 { lab=vcm31}
N -1880 1710 -1820 1710 { lab=vo31}
N -2280 2220 -2280 2250 { lab=#net20}
N -2190 2250 -2100 2250 { lab=#net20}
N -2100 2220 -2100 2250 { lab=#net20}
N -2190 2330 -2170 2330 { lab=GND}
N -2170 2330 -2170 2390 { lab=GND}
N -2190 2250 -2190 2300 { lab=#net20}
N -2170 2190 -2100 2190 { lab=GND}
N -2170 2190 -2170 2330 { lab=GND}
N -1960 2330 -1920 2330 { lab=vbias2}
N -1960 2280 -1960 2330 { lab=vbias2}
N -2260 2280 -1960 2280 { lab=vbias2}
N -2260 2330 -2230 2330 { lab=vbias2}
N -2260 2280 -2260 2330 { lab=vbias2}
N -2190 2360 -2190 2390 { lab=GND}
N -2280 2080 -2280 2160 { lab=#net21}
N -2240 2050 -2140 2050 { lab=#net21}
N -2100 2110 -2100 2160 { lab=#net22}
N -2100 2050 -2080 2050 { lab=vdd}
N -2080 1990 -2080 2050 { lab=vdd}
N -2100 1990 -2080 1990 { lab=vdd}
N -2300 1990 -2300 2050 { lab=vdd}
N -2300 2050 -2280 2050 { lab=vdd}
N -2280 1990 -2280 2020 { lab=vdd}
N -2100 1990 -2100 2020 { lab=vdd}
N -1880 1990 -1880 2080 { lab=vdd}
N -2080 1990 -1880 1990 { lab=vdd}
N -1880 2140 -1880 2300 { lab=vo32}
N -1880 2110 -1860 2110 { lab=vdd}
N -1860 1990 -1860 2110 { lab=vdd}
N -1880 1990 -1860 1990 { lab=vdd}
N -1880 2330 -1860 2330 { lab=GND}
N -1860 2330 -1860 2390 { lab=GND}
N -1880 2360 -1880 2390 { lab=GND}
N -2100 2110 -1920 2110 { lab=#net22}
N -2190 2390 -2170 2390 { lab=GND}
N -2280 2250 -2190 2250 { lab=#net20}
N -2280 2190 -2170 2190 { lab=GND}
N -2460 2280 -2260 2280 { lab=vbias2}
N -2560 2390 -2540 2390 { lab=GND}
N -2540 2390 -2190 2390 { lab=GND}
N -2300 1990 -2280 1990 { lab=vdd}
N -2280 1990 -2100 1990 { lab=vdd}
N -1880 2390 -1860 2390 { lab=GND}
N -2170 2390 -1880 2390 { lab=GND}
N -2100 2080 -2100 2110 { lab=#net22}
N -2640 2390 -2560 2390 { lab=GND}
N -2640 1990 -2300 1990 { lab=vdd}
N -2340 2190 -2320 2190 { lab=vref}
N -2190 2050 -2190 2110 { lab=#net21}
N -2280 2110 -2190 2110 { lab=#net21}
N -2060 2190 -2040 2190 { lab=vcm32}
N -1880 2190 -1820 2190 { lab=vo32}
N -1980 1630 -1980 1650 {
lab=#net19}
N -1980 1710 -1930 1710 {
lab=#net23}
N -1930 1710 -1930 1730 {
lab=#net23}
N -1930 1790 -1880 1790 {
lab=vo31}
N -1980 2110 -1980 2140 {
lab=#net22}
N -1980 2200 -1930 2200 {
lab=#net24}
N -1930 2200 -1930 2210 {
lab=#net24}
N -1930 2270 -1880 2270 {
lab=vo32}
N -3000 2010 -3000 2050 {
lab=GND}
N -3000 2010 -2890 2010 {
lab=GND}
N -2890 2010 -2890 2050 {
lab=GND}
N -3070 2070 -3030 2070 {
lab=vd31}
N -2970 2070 -2920 2070 {
lab=vcm31}
N -2860 2070 -2760 2070 {
lab=vd32}
N -3050 2010 -3000 2010 {
lab=GND}
N -3050 2010 -3050 2020 {
lab=GND}
N -3010 2240 -3010 2280 {
lab=GND}
N -3010 2240 -2900 2240 {
lab=GND}
N -2900 2240 -2900 2280 {
lab=GND}
N -3080 2300 -3040 2300 {
lab=vout3p}
N -2980 2300 -2930 2300 {
lab=vcm32}
N -2870 2300 -2770 2300 {
lab=vout3n}
N -3060 2240 -3010 2240 {
lab=GND}
N -3060 2240 -3060 2250 {
lab=GND}
N -870 1760 -870 1790 { lab=#net25}
N -780 1790 -690 1790 { lab=#net25}
N -690 1760 -690 1790 { lab=#net25}
N -780 1870 -760 1870 { lab=GND}
N -760 1870 -760 1930 { lab=GND}
N -780 1790 -780 1840 { lab=#net25}
N -760 1730 -690 1730 { lab=GND}
N -760 1730 -760 1870 { lab=GND}
N -550 1870 -510 1870 { lab=vbias2}
N -550 1820 -550 1870 { lab=vbias2}
N -850 1820 -550 1820 { lab=vbias2}
N -850 1870 -820 1870 { lab=vbias2}
N -850 1820 -850 1870 { lab=vbias2}
N -780 1900 -780 1930 { lab=GND}
N -870 1620 -870 1700 { lab=#net26}
N -830 1590 -730 1590 { lab=#net26}
N -690 1650 -690 1700 { lab=#net27}
N -690 1590 -670 1590 { lab=vdd}
N -670 1530 -670 1590 { lab=vdd}
N -690 1530 -670 1530 { lab=vdd}
N -890 1530 -890 1590 { lab=vdd}
N -890 1590 -870 1590 { lab=vdd}
N -870 1530 -870 1560 { lab=vdd}
N -690 1530 -690 1560 { lab=vdd}
N -470 1530 -470 1620 { lab=vdd}
N -670 1530 -470 1530 { lab=vdd}
N -470 1680 -470 1840 { lab=vo41}
N -470 1650 -450 1650 { lab=vdd}
N -450 1530 -450 1650 { lab=vdd}
N -470 1530 -450 1530 { lab=vdd}
N -470 1870 -450 1870 { lab=GND}
N -450 1870 -450 1930 { lab=GND}
N -470 1900 -470 1930 { lab=GND}
N -690 1650 -510 1650 { lab=#net27}
N -780 1930 -760 1930 { lab=GND}
N -870 1790 -780 1790 { lab=#net25}
N -870 1730 -760 1730 { lab=GND}
N -1050 1820 -850 1820 { lab=vbias2}
N -1150 1930 -1130 1930 { lab=GND}
N -1130 1930 -780 1930 { lab=GND}
N -890 1530 -870 1530 { lab=vdd}
N -870 1530 -690 1530 { lab=vdd}
N -470 1930 -450 1930 { lab=GND}
N -760 1930 -470 1930 { lab=GND}
N -690 1620 -690 1650 { lab=#net27}
N -1230 1930 -1150 1930 { lab=GND}
N -1230 1530 -890 1530 { lab=vdd}
N -930 1730 -910 1730 { lab=vref}
N -780 1590 -780 1650 { lab=#net26}
N -870 1650 -780 1650 { lab=#net26}
N -650 1730 -630 1730 { lab=vcm41}
N -470 1730 -410 1730 { lab=vo41}
N -870 2240 -870 2270 { lab=#net28}
N -780 2270 -690 2270 { lab=#net28}
N -690 2240 -690 2270 { lab=#net28}
N -780 2350 -760 2350 { lab=GND}
N -760 2350 -760 2410 { lab=GND}
N -780 2270 -780 2320 { lab=#net28}
N -760 2210 -690 2210 { lab=GND}
N -760 2210 -760 2350 { lab=GND}
N -550 2350 -510 2350 { lab=vbias2}
N -550 2300 -550 2350 { lab=vbias2}
N -850 2300 -550 2300 { lab=vbias2}
N -850 2350 -820 2350 { lab=vbias2}
N -850 2300 -850 2350 { lab=vbias2}
N -780 2380 -780 2410 { lab=GND}
N -870 2100 -870 2180 { lab=#net29}
N -830 2070 -730 2070 { lab=#net29}
N -690 2130 -690 2180 { lab=#net30}
N -690 2070 -670 2070 { lab=vdd}
N -670 2010 -670 2070 { lab=vdd}
N -690 2010 -670 2010 { lab=vdd}
N -890 2010 -890 2070 { lab=vdd}
N -890 2070 -870 2070 { lab=vdd}
N -870 2010 -870 2040 { lab=vdd}
N -690 2010 -690 2040 { lab=vdd}
N -470 2010 -470 2100 { lab=vdd}
N -670 2010 -470 2010 { lab=vdd}
N -470 2160 -470 2320 { lab=vo42}
N -470 2130 -450 2130 { lab=vdd}
N -450 2010 -450 2130 { lab=vdd}
N -470 2010 -450 2010 { lab=vdd}
N -470 2350 -450 2350 { lab=GND}
N -450 2350 -450 2410 { lab=GND}
N -470 2380 -470 2410 { lab=GND}
N -690 2130 -510 2130 { lab=#net30}
N -780 2410 -760 2410 { lab=GND}
N -870 2270 -780 2270 { lab=#net28}
N -870 2210 -760 2210 { lab=GND}
N -1050 2300 -850 2300 { lab=vbias2}
N -1150 2410 -1130 2410 { lab=GND}
N -1130 2410 -780 2410 { lab=GND}
N -890 2010 -870 2010 { lab=vdd}
N -870 2010 -690 2010 { lab=vdd}
N -470 2410 -450 2410 { lab=GND}
N -760 2410 -470 2410 { lab=GND}
N -690 2100 -690 2130 { lab=#net30}
N -1230 2410 -1150 2410 { lab=GND}
N -1230 2010 -890 2010 { lab=vdd}
N -930 2210 -910 2210 { lab=vref}
N -780 2070 -780 2130 { lab=#net29}
N -870 2130 -780 2130 { lab=#net29}
N -650 2210 -630 2210 { lab=vcm42}
N -470 2210 -410 2210 { lab=vo42}
N -570 1650 -570 1670 {
lab=#net27}
N -570 1730 -520 1730 {
lab=#net31}
N -520 1730 -520 1750 {
lab=#net31}
N -520 1810 -470 1810 {
lab=vo41}
N -570 2130 -570 2160 {
lab=#net30}
N -570 2220 -520 2220 {
lab=#net32}
N -520 2220 -520 2230 {
lab=#net32}
N -520 2290 -470 2290 {
lab=vo42}
N -1590 2030 -1590 2070 {
lab=GND}
N -1590 2030 -1480 2030 {
lab=GND}
N -1480 2030 -1480 2070 {
lab=GND}
N -1660 2090 -1620 2090 {
lab=vd41}
N -1560 2090 -1510 2090 {
lab=vcm41}
N -1450 2090 -1350 2090 {
lab=vd42}
N -1640 2030 -1590 2030 {
lab=GND}
N -1640 2030 -1640 2040 {
lab=GND}
N -1600 2260 -1600 2300 {
lab=GND}
N -1600 2260 -1490 2260 {
lab=GND}
N -1490 2260 -1490 2300 {
lab=GND}
N -1670 2320 -1630 2320 {
lab=vout4p}
N -1570 2320 -1520 2320 {
lab=vcm42}
N -1460 2320 -1360 2320 {
lab=vout4n}
N -1650 2260 -1600 2260 {
lab=GND}
N -1650 2260 -1650 2270 {
lab=GND}
N 510 1730 510 1760 { lab=#net33}
N 600 1760 690 1760 { lab=#net33}
N 690 1730 690 1760 { lab=#net33}
N 600 1840 620 1840 { lab=GND}
N 620 1840 620 1900 { lab=GND}
N 600 1760 600 1810 { lab=#net33}
N 620 1700 690 1700 { lab=GND}
N 620 1700 620 1840 { lab=GND}
N 830 1840 870 1840 { lab=vbias2}
N 830 1790 830 1840 { lab=vbias2}
N 530 1790 830 1790 { lab=vbias2}
N 530 1840 560 1840 { lab=vbias2}
N 530 1790 530 1840 { lab=vbias2}
N 600 1870 600 1900 { lab=GND}
N 510 1590 510 1670 { lab=#net34}
N 550 1560 650 1560 { lab=#net34}
N 690 1620 690 1670 { lab=#net35}
N 690 1560 710 1560 { lab=vdd}
N 710 1500 710 1560 { lab=vdd}
N 690 1500 710 1500 { lab=vdd}
N 490 1500 490 1560 { lab=vdd}
N 490 1560 510 1560 { lab=vdd}
N 510 1500 510 1530 { lab=vdd}
N 690 1500 690 1530 { lab=vdd}
N 910 1500 910 1590 { lab=vdd}
N 710 1500 910 1500 { lab=vdd}
N 910 1650 910 1810 { lab=vo51}
N 910 1620 930 1620 { lab=vdd}
N 930 1500 930 1620 { lab=vdd}
N 910 1500 930 1500 { lab=vdd}
N 910 1840 930 1840 { lab=GND}
N 930 1840 930 1900 { lab=GND}
N 910 1870 910 1900 { lab=GND}
N 690 1620 870 1620 { lab=#net35}
N 600 1900 620 1900 { lab=GND}
N 510 1760 600 1760 { lab=#net33}
N 510 1700 620 1700 { lab=GND}
N 330 1790 530 1790 { lab=vbias2}
N 230 1900 250 1900 { lab=GND}
N 250 1900 600 1900 { lab=GND}
N 490 1500 510 1500 { lab=vdd}
N 510 1500 690 1500 { lab=vdd}
N 910 1900 930 1900 { lab=GND}
N 620 1900 910 1900 { lab=GND}
N 690 1590 690 1620 { lab=#net35}
N 150 1900 230 1900 { lab=GND}
N 150 1500 490 1500 { lab=vdd}
N 450 1700 470 1700 { lab=vref}
N 600 1560 600 1620 { lab=#net34}
N 510 1620 600 1620 { lab=#net34}
N 730 1700 750 1700 { lab=vcm51}
N 910 1700 970 1700 { lab=vo51}
N 510 2210 510 2240 { lab=#net36}
N 600 2240 690 2240 { lab=#net36}
N 690 2210 690 2240 { lab=#net36}
N 600 2320 620 2320 { lab=GND}
N 620 2320 620 2380 { lab=GND}
N 600 2240 600 2290 { lab=#net36}
N 620 2180 690 2180 { lab=GND}
N 620 2180 620 2320 { lab=GND}
N 830 2320 870 2320 { lab=vbias2}
N 830 2270 830 2320 { lab=vbias2}
N 530 2270 830 2270 { lab=vbias2}
N 530 2320 560 2320 { lab=vbias2}
N 530 2270 530 2320 { lab=vbias2}
N 600 2350 600 2380 { lab=GND}
N 510 2070 510 2150 { lab=#net37}
N 550 2040 650 2040 { lab=#net37}
N 690 2100 690 2150 { lab=#net38}
N 690 2040 710 2040 { lab=vdd}
N 710 1980 710 2040 { lab=vdd}
N 690 1980 710 1980 { lab=vdd}
N 490 1980 490 2040 { lab=vdd}
N 490 2040 510 2040 { lab=vdd}
N 510 1980 510 2010 { lab=vdd}
N 690 1980 690 2010 { lab=vdd}
N 910 1980 910 2070 { lab=vdd}
N 710 1980 910 1980 { lab=vdd}
N 910 2130 910 2290 { lab=vo52}
N 910 2100 930 2100 { lab=vdd}
N 930 1980 930 2100 { lab=vdd}
N 910 1980 930 1980 { lab=vdd}
N 910 2320 930 2320 { lab=GND}
N 930 2320 930 2380 { lab=GND}
N 910 2350 910 2380 { lab=GND}
N 690 2100 870 2100 { lab=#net38}
N 600 2380 620 2380 { lab=GND}
N 510 2240 600 2240 { lab=#net36}
N 510 2180 620 2180 { lab=GND}
N 330 2270 530 2270 { lab=vbias2}
N 230 2380 250 2380 { lab=GND}
N 250 2380 600 2380 { lab=GND}
N 490 1980 510 1980 { lab=vdd}
N 510 1980 690 1980 { lab=vdd}
N 910 2380 930 2380 { lab=GND}
N 620 2380 910 2380 { lab=GND}
N 690 2070 690 2100 { lab=#net38}
N 150 2380 230 2380 { lab=GND}
N 150 1980 490 1980 { lab=vdd}
N 450 2180 470 2180 { lab=vref}
N 600 2040 600 2100 { lab=#net37}
N 510 2100 600 2100 { lab=#net37}
N 730 2180 750 2180 { lab=vcm52}
N 910 2180 970 2180 { lab=vo52}
N 810 1620 810 1640 {
lab=#net35}
N 810 1700 860 1700 {
lab=#net39}
N 860 1700 860 1720 {
lab=#net39}
N 860 1780 910 1780 {
lab=vo51}
N 810 2100 810 2130 {
lab=#net38}
N 810 2190 860 2190 {
lab=#net40}
N 860 2190 860 2200 {
lab=#net40}
N 860 2260 910 2260 {
lab=vo52}
N -210 2000 -210 2040 {
lab=GND}
N -210 2000 -100 2000 {
lab=GND}
N -100 2000 -100 2040 {
lab=GND}
N -280 2060 -240 2060 {
lab=vd51}
N -180 2060 -130 2060 {
lab=vcm51}
N -70 2060 30 2060 {
lab=vd52}
N -260 2000 -210 2000 {
lab=GND}
N -260 2000 -260 2010 {
lab=GND}
N -220 2230 -220 2270 {
lab=GND}
N -220 2230 -110 2230 {
lab=GND}
N -110 2230 -110 2270 {
lab=GND}
N -290 2290 -250 2290 {
lab=vout5p}
N -190 2290 -140 2290 {
lab=vcm52}
N -80 2290 20 2290 {
lab=vout5n}
N -270 2230 -220 2230 {
lab=GND}
N -270 2230 -270 2240 {
lab=GND}
N -830 -1680 -830 -1670 {
lab=GND}
N -830 -1190 -830 -1180 {
lab=GND}
N 660 -1680 660 -1670 {
lab=GND}
N 660 -1190 660 -1180 {
lab=GND}
N -2000 1680 -2000 1690 {
lab=GND}
N -2000 2170 -2000 2180 {
lab=GND}
N -590 1700 -590 1710 {
lab=GND}
N -590 2190 -590 2200 {
lab=GND}
N 790 1670 790 1680 {
lab=GND}
N 790 2160 790 2170 {
lab=GND}
N -2400 10 -2340 10 {
lab=vgs9}
N -2400 -50 -2400 10 {
lab=vgs9}
N -2400 -50 -2300 -50 {
lab=vgs9}
N -2300 -50 -2300 -20 {
lab=vgs9}
N -2300 40 -2300 80 {
lab=GND}
N -2300 -80 -2300 -50 {
lab=vgs9}
N -2300 -180 -2300 -140 {
lab=vdd}
N -2300 -190 -2300 -180 {
lab=vdd}
N -2300 10 -2230 10 {
lab=GND}
N -2300 60 -2230 60 {
lab=GND}
N -2230 10 -2230 60 {
lab=GND}
N 2490 1160 2530 1160 {
lab=GND}
N 2490 1160 2490 1310 {
lab=GND}
N 2490 1310 2550 1310 {
lab=GND}
N 2710 1160 2760 1160 {
lab=GND}
N 2710 1160 2710 1310 {
lab=GND}
N 2710 1310 2780 1310 {
lab=GND}
N -2640 30 -2580 30 {
lab=vgs8}
N -2640 -30 -2640 30 {
lab=vgs8}
N -2640 -30 -2540 -30 {
lab=vgs8}
N -2540 -30 -2540 0 {
lab=vgs8}
N -2540 60 -2540 100 {
lab=GND}
N -2540 -60 -2540 -30 {
lab=vgs8}
N -2540 -160 -2540 -120 {
lab=vdd}
N -2540 -170 -2540 -160 {
lab=vdd}
N -2540 30 -2470 30 {
lab=GND}
N -2540 80 -2470 80 {
lab=GND}
N -2470 30 -2470 80 {
lab=GND}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1410 -500 0 0 {name=R1
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1180 -500 0 0 {name=R2
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1290 -450 1 0 {name=R3
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -900 -490 0 0 {name=R4
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -670 -490 0 0 {name=R5
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -780 -440 1 0 {name=R6
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1430 -160 0 0 {name=M1
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1200 -270 0 0 {name=M2
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -880 -270 0 1 {name=M3
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -650 -180 0 1 {name=M4
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1070 -150 0 0 {name=M5
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1070 60 0 0 {name=M6
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -1050 120 0 0 {name=l2 lab=GND}
C {gnd.sym} -1050 -90 0 0 {name=l3 lab=GND}
C {gnd.sym} -1440 -500 0 0 {name=l8 lab=GND}
C {gnd.sym} -1250 -480 0 0 {name=l9 lab=GND}
C {gnd.sym} -940 -490 0 0 {name=l10 lab=GND}
C {gnd.sym} -730 -470 0 0 {name=l11 lab=GND}
C {gnd.sym} -1340 -160 0 0 {name=l12 lab=GND}
C {gnd.sym} -1050 -230 0 0 {name=l13 lab=GND}
C {gnd.sym} -720 -180 0 0 {name=l14 lab=GND}
C {lab_pin.sym} -1410 30 0 0 {name=l15 sig_type=std_logic lab=vs11}
C {lab_pin.sym} -1410 -350 0 0 {name=l16 sig_type=std_logic lab=vd11}
C {lab_pin.sym} -1180 -390 0 0 {name=l17 sig_type=std_logic lab=vout1p}
C {lab_pin.sym} -1180 -200 0 0 {name=l18 sig_type=std_logic lab=vs12}
C {lab_pin.sym} -900 -390 0 0 {name=l25 sig_type=std_logic lab=vout1n}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -120 -520 0 0 {name=R7
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 110 -520 0 0 {name=R8
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 0 -470 1 0 {name=R9
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 390 -510 0 0 {name=R10
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 620 -510 0 0 {name=R11
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 510 -460 1 0 {name=R12
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -140 -180 0 0 {name=M7
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 90 -290 0 0 {name=M8
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 410 -290 0 1 {name=M10
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 640 -200 0 1 {name=M11
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 220 -170 0 0 {name=M12
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 220 40 0 0 {name=M13
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 240 100 0 0 {name=l19 lab=GND}
C {gnd.sym} 240 -110 0 0 {name=l20 lab=GND}
C {gnd.sym} -150 -520 0 0 {name=l24 lab=GND}
C {gnd.sym} 40 -500 0 0 {name=l27 lab=GND}
C {gnd.sym} 350 -510 0 0 {name=l28 lab=GND}
C {gnd.sym} 560 -490 0 0 {name=l29 lab=GND}
C {gnd.sym} -50 -180 0 0 {name=l30 lab=GND}
C {gnd.sym} 240 -250 0 0 {name=l33 lab=GND}
C {gnd.sym} 570 -200 0 0 {name=l34 lab=GND}
C {lab_pin.sym} -120 10 0 0 {name=l35 sig_type=std_logic lab=vs21}
C {lab_pin.sym} -120 -370 0 0 {name=l36 sig_type=std_logic lab=vd21}
C {lab_pin.sym} 110 -410 0 0 {name=l37 sig_type=std_logic lab=vout2p}
C {lab_pin.sym} 110 -220 0 0 {name=l38 sig_type=std_logic lab=vs22}
C {lab_pin.sym} 390 -410 0 0 {name=l39 sig_type=std_logic lab=vout2n}
C {lab_pin.sym} -200 -180 0 0 {name=l40 sig_type=std_logic lab=vout1p}
C {lab_pin.sym} 110 -170 0 0 {name=l41 sig_type=std_logic lab=vo22
}
C {lab_pin.sym} 90 40 0 0 {name=l42 sig_type=std_logic lab=vo21
}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1410 550 0 0 {name=R13
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1180 550 0 0 {name=R14
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1290 600 1 0 {name=R15
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -900 560 0 0 {name=R16
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -670 560 0 0 {name=R17
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -780 610 1 0 {name=R18
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1430 890 0 0 {name=M14
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1200 780 0 0 {name=M15
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -880 780 0 1 {name=M16
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -650 870 0 1 {name=M17
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1070 900 0 0 {name=M18
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1070 1110 0 0 {name=M19
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -1050 1170 0 0 {name=l43 lab=GND}
C {gnd.sym} -1050 960 0 0 {name=l44 lab=GND}
C {gnd.sym} -1440 550 0 0 {name=l48 lab=GND}
C {gnd.sym} -1250 570 0 0 {name=l49 lab=GND}
C {gnd.sym} -940 560 0 0 {name=l50 lab=GND}
C {gnd.sym} -730 580 0 0 {name=l51 lab=GND}
C {gnd.sym} -1340 890 0 0 {name=l52 lab=GND}
C {gnd.sym} -1050 820 0 0 {name=l53 lab=GND}
C {gnd.sym} -720 870 0 0 {name=l54 lab=GND}
C {lab_pin.sym} -1410 1080 0 0 {name=l55 sig_type=std_logic lab=vs41}
C {lab_pin.sym} -1410 700 0 0 {name=l56 sig_type=std_logic lab=vd41}
C {lab_pin.sym} -1180 660 0 0 {name=l57 sig_type=std_logic lab=vout4p}
C {lab_pin.sym} -1180 850 0 0 {name=l58 sig_type=std_logic lab=vs42}
C {lab_pin.sym} -900 660 0 0 {name=l59 sig_type=std_logic lab=vout4n}
C {lab_pin.sym} -1570 890 0 0 {name=l60 sig_type=std_logic lab=vout3p}
C {lab_pin.sym} -1180 900 0 0 {name=l61 sig_type=std_logic lab=vo42
}
C {lab_pin.sym} -1200 1110 0 0 {name=l62 sig_type=std_logic lab=vo41
}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -2580 560 0 0 {name=R25
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -2350 560 0 0 {name=R26
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -2460 610 1 0 {name=R27
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -2070 570 0 0 {name=R28
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1840 570 0 0 {name=R29
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1950 620 1 0 {name=R30
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2600 900 0 0 {name=M26
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2370 790 0 0 {name=M27
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2050 790 0 1 {name=M28
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1820 880 0 1 {name=M29
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2240 910 0 0 {name=M30
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2240 1120 0 0 {name=M31
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2220 1180 0 0 {name=l83 lab=GND}
C {gnd.sym} -2220 970 0 0 {name=l84 lab=GND}
C {gnd.sym} -2610 560 0 0 {name=l88 lab=GND}
C {gnd.sym} -2420 580 0 0 {name=l89 lab=GND}
C {gnd.sym} -2110 570 0 0 {name=l90 lab=GND}
C {gnd.sym} -1900 590 0 0 {name=l91 lab=GND}
C {gnd.sym} -2510 900 0 0 {name=l92 lab=GND}
C {gnd.sym} -2220 830 0 0 {name=l93 lab=GND}
C {gnd.sym} -1890 880 0 0 {name=l94 lab=GND}
C {lab_pin.sym} -2580 1090 0 0 {name=l95 sig_type=std_logic lab=vs31}
C {lab_pin.sym} -2580 710 0 0 {name=l96 sig_type=std_logic lab=vd31}
C {lab_pin.sym} -2350 670 0 0 {name=l97 sig_type=std_logic lab=vout3p}
C {lab_pin.sym} -2350 860 0 0 {name=l98 sig_type=std_logic lab=vs32}
C {lab_pin.sym} -2070 670 0 0 {name=l99 sig_type=std_logic lab=vout3n}
C {lab_pin.sym} -2350 910 0 0 {name=l101 sig_type=std_logic lab=vo32
}
C {lab_pin.sym} -2370 1120 0 0 {name=l102 sig_type=std_logic lab=vo31
}
C {lab_pin.sym} -670 -380 0 0 {name=l103 sig_type=std_logic lab=vd12}
C {lab_pin.sym} 770 -200 0 0 {name=l22 sig_type=std_logic lab=vout1n}
C {lab_pin.sym} 620 -380 0 0 {name=l104 sig_type=std_logic lab=vd22}
C {lab_pin.sym} -1840 690 0 0 {name=l85 sig_type=std_logic lab=vd32}
C {lab_pin.sym} -2740 900 0 0 {name=l86 sig_type=std_logic lab=vout2p}
C {lab_pin.sym} -1680 880 0 0 {name=l100 sig_type=std_logic lab=vout2n}
C {lab_pin.sym} -670 670 0 0 {name=l105 sig_type=std_logic lab=vd42}
C {lab_pin.sym} -510 870 0 0 {name=l45 sig_type=std_logic lab=vout3n
}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -150 570 0 0 {name=R19
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 80 570 0 0 {name=R20
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -30 620 1 0 {name=R21
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 360 580 0 0 {name=R22
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 590 580 0 0 {name=R23
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 480 630 1 0 {name=R24
W=5.73
L=7.5
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -170 910 0 0 {name=M20
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 60 800 0 0 {name=M21
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 380 800 0 1 {name=M22
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 610 890 0 1 {name=M23
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 190 920 0 0 {name=M24
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 190 1130 0 0 {name=M25
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 210 1190 0 0 {name=l46 lab=GND}
C {gnd.sym} 210 980 0 0 {name=l63 lab=GND}
C {gnd.sym} -180 570 0 0 {name=l65 lab=GND}
C {gnd.sym} 10 590 0 0 {name=l66 lab=GND}
C {gnd.sym} 320 580 0 0 {name=l67 lab=GND}
C {gnd.sym} 530 600 0 0 {name=l68 lab=GND}
C {gnd.sym} -80 910 0 0 {name=l69 lab=GND}
C {gnd.sym} 210 840 0 0 {name=l70 lab=GND}
C {gnd.sym} 540 890 0 0 {name=l71 lab=GND}
C {lab_pin.sym} -150 1100 0 0 {name=l72 sig_type=std_logic lab=vs51}
C {lab_pin.sym} -150 720 0 0 {name=l73 sig_type=std_logic lab=vd51}
C {lab_pin.sym} 80 680 0 0 {name=l74 sig_type=std_logic lab=vout5p}
C {lab_pin.sym} 80 870 0 0 {name=l75 sig_type=std_logic lab=vs52}
C {lab_pin.sym} 360 680 0 0 {name=l76 sig_type=std_logic lab=vout5n}
C {lab_pin.sym} -310 910 0 0 {name=l77 sig_type=std_logic lab=vout4p}
C {lab_pin.sym} 80 920 0 0 {name=l78 sig_type=std_logic lab=vo52
}
C {lab_pin.sym} 60 1130 0 0 {name=l79 sig_type=std_logic lab=vo51
}
C {lab_pin.sym} 590 690 0 0 {name=l80 sig_type=std_logic lab=vd52}
C {lab_pin.sym} 750 890 0 0 {name=l81 sig_type=std_logic lab=vout4n
}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1210 590 0 0 {name=R36
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1950 600 0 0 {name=R40
W=5.73
L=2.96
model=res_xhigh_po_5p73
spiceprefix=X
mult=5}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1190 930 0 0 {name=M34
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1970 910 0 1 {name=M37
L=0.15
W=61
nf=61
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1550 1150 0 0 {name=M39
L=0.15
W=172
nf=172
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 1570 1210 0 0 {name=l119 lab=GND}
C {gnd.sym} 1180 590 0 0 {name=l124 lab=GND}
C {gnd.sym} 1280 930 0 0 {name=l128 lab=GND}
C {gnd.sym} 1900 910 0 0 {name=l130 lab=GND}
C {lab_pin.sym} 1210 1120 0 0 {name=l131 sig_type=std_logic lab=vst}
C {lab_pin.sym} 1420 1150 0 0 {name=l138 sig_type=std_logic lab=vgs8
}
C {gnd.sym} 1890 600 0 0 {name=l21 lab=GND}
C {lab_pin.sym} 1210 760 0 0 {name=l26 sig_type=std_logic lab=vfbn}
C {lab_pin.sym} 1950 750 0 0 {name=l109 sig_type=std_logic lab=vfbp}
C {lab_pin.sym} 2100 910 0 0 {name=l110 sig_type=std_logic lab=vout5n}
C {lab_pin.sym} 1050 930 0 0 {name=l113 sig_type=std_logic lab=vout5p}
C {gnd.sym} -1740 -60 0 0 {name=l107 lab=GND}
C {gnd.sym} -500 -60 0 0 {name=l5 lab=GND}
C {lab_pin.sym} -1530 -160 0 0 {name=l6 sig_type=std_logic lab=vinp}
C {lab_pin.sym} -550 -180 0 0 {name=l108 sig_type=std_logic lab=vinn}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1460 0 0 0 {name=M41
L=0.15
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1680 0 0 1 {name=M42
L=0.15
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1550 110 0 0 {name=M43
L=0.15
W=1
nf=1
mult=28
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 1570 160 0 0 {name=l145 lab=GND}
C {gnd.sym} 1570 40 0 0 {name=l146 lab=GND}
C {lab_pin.sym} 1480 -90 0 0 {name=l114 sig_type=std_logic lab=vd11}
C {lab_pin.sym} 1660 -90 0 0 {name=l115 sig_type=std_logic lab=vd12}
C {lab_pin.sym} 1480 110 0 0 {name=l151 sig_type=std_logic lab=vgs9
}
C {lab_pin.sym} 1390 0 0 0 {name=l136 sig_type=std_logic lab=vin0p}
C {lab_pin.sym} 1770 0 0 0 {name=l139 sig_type=std_logic lab=vin0n}
C {gnd.sym} 2550 1330 0 0 {name=l120 lab=GND}
C {gnd.sym} 2780 1330 0 0 {name=l121 lab=GND}
C {lab_pin.sym} 2780 1100 0 0 {name=l125 sig_type=std_logic lab=vfbp}
C {lab_pin.sym} 2780 1210 0 0 {name=l127 sig_type=std_logic lab=vin0n}
C {lab_pin.sym} 2550 1100 0 0 {name=l122 sig_type=std_logic lab=vfbn}
C {lab_pin.sym} 2550 1210 0 0 {name=l126 sig_type=std_logic lab=vin0p}
C {capa.sym} 2550 1260 0 0 {name=C1
m=1
value=2u
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 2780 1260 0 0 {name=C2
m=1
value=2u
footprint=1206
device="ceramic capacitor"}
C {vsource.sym} -1830 -30 0 0 {name=V9 value=0
}
C {gnd.sym} -1830 50 0 0 {name=l111 lab=GND}
C {lab_pin.sym} -1830 -90 0 0 {name=l112 sig_type=std_logic lab=vc}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 0 -400 3 0 {name=M32
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 510 -410 3 0 {name=M33
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} 0 -360 0 0 {name=l116 sig_type=std_logic lab=vc}
C {lab_pin.sym} 510 -370 0 0 {name=l117 sig_type=std_logic lab=vc}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} -30 680 3 0 {name=M35
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 480 690 3 0 {name=M36
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} -30 720 0 0 {name=l118 sig_type=std_logic lab=vc}
C {lab_pin.sym} 480 740 0 0 {name=l129 sig_type=std_logic lab=vc}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} -1290 650 3 0 {name=M38
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} -770 660 3 0 {name=M40
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} -1290 700 0 0 {name=l132 sig_type=std_logic lab=vc}
C {lab_pin.sym} -770 700 0 0 {name=l133 sig_type=std_logic lab=vc}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} -2460 670 3 0 {name=M44
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} -1950 680 3 0 {name=M45
L=0.15
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} -2460 710 0 0 {name=l134 sig_type=std_logic lab=vc}
C {lab_pin.sym} -1950 720 0 0 {name=l135 sig_type=std_logic lab=vc}
C {vsource.sym} -2020 -20 0 0 {name=V11 value="DC 1.2 "}
C {gnd.sym} -2020 30 0 0 {name=l31 lab=GND}
C {lab_pin.sym} -2020 -60 0 0 {name=l32 sig_type=std_logic lab=vref}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1350 -1510 0 1 {name=M9
L=2
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1130 -1650 0 0 {name=M46
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -910 -1650 0 1 {name=M47
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1040 -1510 0 0 {name=M48
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -730 -1510 0 0 {name=M49
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -950 -1790 0 0 {name=M50
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -1090 -1790 0 1 {name=M51
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -730 -1730 0 0 {name=M52
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {vsource.sym} -1470 -1790 0 0 {name=V3 value=1.8}
C {gnd.sym} -1470 -1740 0 0 {name=l137 lab=GND}
C {gnd.sym} -1470 -1450 0 0 {name=l140 lab=GND}
C {isource.sym} -1470 -1520 2 0 {name=I0 value=40u}
C {lab_pin.sym} -660 -1650 0 0 {name=l147 sig_type=std_logic lab=vo}
C {lab_pin.sym} -1170 -1650 0 0 {name=l148 sig_type=std_logic lab=vref}
C {lab_pin.sym} -870 -1650 1 1 {name=l149 sig_type=std_logic lab=vcm}
C {sky130_fd_pr/cap_mim_m3_1.sym} -760 -1600 0 0 {name=C3 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1130 -1170 0 0 {name=M54
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -910 -1170 0 1 {name=M55
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1040 -1030 0 0 {name=M56
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -730 -1030 0 0 {name=M57
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -950 -1310 0 0 {name=M58
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -1090 -1310 0 1 {name=M59
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -730 -1250 0 0 {name=M60
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} -660 -1170 0 0 {name=l154 sig_type=std_logic lab=vo2}
C {lab_pin.sym} -1170 -1170 0 0 {name=l155 sig_type=std_logic lab=vref}
C {lab_pin.sym} -870 -1170 1 1 {name=l156 sig_type=std_logic lab=vcm2}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1830 -1290 1 0 {name=R35
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1720 -1290 1 0 {name=R37
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -1880 -1340 0 0 {name=l157 lab=GND}
C {lab_pin.sym} -1900 -1290 0 0 {name=l158 sig_type=std_logic lab=vd11}
C {lab_pin.sym} -1590 -1290 0 0 {name=l159 sig_type=std_logic lab=vd12}
C {lab_pin.sym} -1770 -1290 1 1 {name=l160 sig_type=std_logic lab=vcm}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1840 -1060 1 0 {name=R38
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1730 -1060 1 0 {name=R39
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -1890 -1110 0 0 {name=l161 lab=GND}
C {lab_pin.sym} -1780 -1060 1 1 {name=l164 sig_type=std_logic lab=vcm2}
C {lab_pin.sym} -1910 -1060 0 0 {name=l141 sig_type=std_logic lab=vout1p}
C {lab_pin.sym} -1610 -1060 0 0 {name=l142 sig_type=std_logic lab=vout1n}
C {lab_pin.sym} -1200 60 0 0 {name=l1 sig_type=std_logic lab=vo}
C {lab_pin.sym} -1180 -150 0 0 {name=l4 sig_type=std_logic lab=vo2}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 360 -1650 0 0 {name=M62
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 580 -1650 0 1 {name=M63
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 450 -1510 0 0 {name=M64
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 760 -1510 0 0 {name=M65
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 540 -1790 0 0 {name=M66
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 400 -1790 0 1 {name=M67
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 760 -1730 0 0 {name=M68
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 20 -1450 0 0 {name=l144 lab=GND}
C {lab_pin.sym} 830 -1650 0 0 {name=l153 sig_type=std_logic lab=vo21}
C {lab_pin.sym} 320 -1650 0 0 {name=l162 sig_type=std_logic lab=vref}
C {lab_pin.sym} 620 -1650 1 1 {name=l163 sig_type=std_logic lab=vcm21}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 360 -1170 0 0 {name=M70
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 580 -1170 0 1 {name=M71
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 450 -1030 0 0 {name=M72
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 760 -1030 0 0 {name=M73
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 540 -1310 0 0 {name=M74
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 400 -1310 0 1 {name=M75
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 760 -1250 0 0 {name=M76
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 20 -970 0 0 {name=l166 lab=GND}
C {lab_pin.sym} 830 -1170 0 0 {name=l167 sig_type=std_logic lab=vo22}
C {lab_pin.sym} 320 -1170 0 0 {name=l168 sig_type=std_logic lab=vref}
C {lab_pin.sym} 620 -1170 1 1 {name=l169 sig_type=std_logic lab=vcm22}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -340 -1290 1 0 {name=R43
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -230 -1290 1 0 {name=R44
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -390 -1340 0 0 {name=l170 lab=GND}
C {lab_pin.sym} -410 -1290 0 0 {name=l171 sig_type=std_logic lab=vd21}
C {lab_pin.sym} -100 -1290 0 0 {name=l172 sig_type=std_logic lab=vd22}
C {lab_pin.sym} -280 -1290 1 1 {name=l173 sig_type=std_logic lab=vcm21}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -350 -1060 1 0 {name=R45
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -240 -1060 1 0 {name=R46
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -400 -1110 0 0 {name=l174 lab=GND}
C {lab_pin.sym} -290 -1060 1 1 {name=l175 sig_type=std_logic lab=vcm22}
C {lab_pin.sym} -420 -1060 0 0 {name=l176 sig_type=std_logic lab=vout2p}
C {lab_pin.sym} -120 -1060 0 0 {name=l177 sig_type=std_logic lab=vout2n}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2300 1710 0 0 {name=M78
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2080 1710 0 1 {name=M79
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2210 1850 0 0 {name=M80
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1900 1850 0 0 {name=M81
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -2120 1570 0 0 {name=M82
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -2260 1570 0 1 {name=M83
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -1900 1630 0 0 {name=M84
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2640 1910 0 0 {name=l179 lab=GND}
C {lab_pin.sym} -1830 1710 0 0 {name=l180 sig_type=std_logic lab=vo31}
C {lab_pin.sym} -2340 1710 0 0 {name=l181 sig_type=std_logic lab=vref}
C {lab_pin.sym} -2040 1710 1 1 {name=l182 sig_type=std_logic lab=vcm31}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2300 2190 0 0 {name=M86
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2080 2190 0 1 {name=M87
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2210 2330 0 0 {name=M88
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -1900 2330 0 0 {name=M89
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -2120 2050 0 0 {name=M90
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -2260 2050 0 1 {name=M91
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -1900 2110 0 0 {name=M92
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2640 2390 0 0 {name=l184 lab=GND}
C {lab_pin.sym} -1830 2190 0 0 {name=l185 sig_type=std_logic lab=vo32}
C {lab_pin.sym} -2340 2190 0 0 {name=l186 sig_type=std_logic lab=vref}
C {lab_pin.sym} -2040 2190 1 1 {name=l187 sig_type=std_logic lab=vcm32}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -3000 2070 1 0 {name=R49
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -2890 2070 1 0 {name=R50
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -3050 2020 0 0 {name=l188 lab=GND}
C {lab_pin.sym} -3070 2070 0 0 {name=l189 sig_type=std_logic lab=vd31}
C {lab_pin.sym} -2760 2070 0 0 {name=l190 sig_type=std_logic lab=vd32}
C {lab_pin.sym} -2940 2070 1 1 {name=l191 sig_type=std_logic lab=vcm31}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -3010 2300 1 0 {name=R51
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -2900 2300 1 0 {name=R52
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -3060 2250 0 0 {name=l192 lab=GND}
C {lab_pin.sym} -2950 2300 1 1 {name=l193 sig_type=std_logic lab=vcm32}
C {lab_pin.sym} -3080 2300 0 0 {name=l194 sig_type=std_logic lab=vout3p}
C {lab_pin.sym} -2780 2300 0 0 {name=l195 sig_type=std_logic lab=vout3n}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -890 1730 0 0 {name=M94
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -670 1730 0 1 {name=M95
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -800 1870 0 0 {name=M96
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -490 1870 0 0 {name=M97
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -710 1590 0 0 {name=M98
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -850 1590 0 1 {name=M99
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -490 1650 0 0 {name=M100
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -1230 1930 0 0 {name=l197 lab=GND}
C {lab_pin.sym} -420 1730 0 0 {name=l198 sig_type=std_logic lab=vo41}
C {lab_pin.sym} -930 1730 0 0 {name=l199 sig_type=std_logic lab=vref}
C {lab_pin.sym} -630 1730 1 1 {name=l200 sig_type=std_logic lab=vcm41}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -890 2210 0 0 {name=M102
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -670 2210 0 1 {name=M103
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -800 2350 0 0 {name=M104
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -490 2350 0 0 {name=M105
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -710 2070 0 0 {name=M106
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -850 2070 0 1 {name=M107
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -490 2130 0 0 {name=M108
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -1230 2410 0 0 {name=l202 lab=GND}
C {lab_pin.sym} -420 2210 0 0 {name=l203 sig_type=std_logic lab=vo42}
C {lab_pin.sym} -930 2210 0 0 {name=l204 sig_type=std_logic lab=vref}
C {lab_pin.sym} -630 2210 1 1 {name=l205 sig_type=std_logic lab=vcm42}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1590 2090 1 0 {name=R55
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1480 2090 1 0 {name=R56
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -1640 2040 0 0 {name=l206 lab=GND}
C {lab_pin.sym} -1660 2090 0 0 {name=l207 sig_type=std_logic lab=vd41}
C {lab_pin.sym} -1350 2090 0 0 {name=l208 sig_type=std_logic lab=vd42}
C {lab_pin.sym} -1530 2090 1 1 {name=l209 sig_type=std_logic lab=vcm41}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1600 2320 1 0 {name=R57
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -1490 2320 1 0 {name=R58
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -1650 2270 0 0 {name=l210 lab=GND}
C {lab_pin.sym} -1540 2320 1 1 {name=l211 sig_type=std_logic lab=vcm42}
C {lab_pin.sym} -1670 2320 0 0 {name=l212 sig_type=std_logic lab=vout4p}
C {lab_pin.sym} -1370 2320 0 0 {name=l213 sig_type=std_logic lab=vout4n}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 490 1700 0 0 {name=M110
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 710 1700 0 1 {name=M111
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 580 1840 0 0 {name=M112
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 890 1840 0 0 {name=M113
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 670 1560 0 0 {name=M114
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 530 1560 0 1 {name=M115
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 890 1620 0 0 {name=M116
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 150 1900 0 0 {name=l215 lab=GND}
C {lab_pin.sym} 960 1700 0 0 {name=l216 sig_type=std_logic lab=vo51}
C {lab_pin.sym} 450 1700 0 0 {name=l217 sig_type=std_logic lab=vref}
C {lab_pin.sym} 750 1700 1 1 {name=l218 sig_type=std_logic lab=vcm51}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 490 2180 0 0 {name=M118
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 710 2180 0 1 {name=M119
L=0.25
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 580 2320 0 0 {name=M120
L=2
W=1
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 890 2320 0 0 {name=M121
L=2
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 670 2040 0 0 {name=M122
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 530 2040 0 1 {name=M123
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 890 2100 0 0 {name=M124
L=0.5
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} 150 2380 0 0 {name=l220 lab=GND}
C {lab_pin.sym} 960 2180 0 0 {name=l221 sig_type=std_logic lab=vo52}
C {lab_pin.sym} 450 2180 0 0 {name=l222 sig_type=std_logic lab=vref}
C {lab_pin.sym} 750 2180 1 1 {name=l223 sig_type=std_logic lab=vcm52}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -210 2060 1 0 {name=R61
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -100 2060 1 0 {name=R62
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -260 2010 0 0 {name=l224 lab=GND}
C {lab_pin.sym} -280 2060 0 0 {name=l225 sig_type=std_logic lab=vd51}
C {lab_pin.sym} 30 2060 0 0 {name=l226 sig_type=std_logic lab=vd52}
C {lab_pin.sym} -150 2060 1 1 {name=l227 sig_type=std_logic lab=vcm51}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -220 2290 1 0 {name=R63
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} -110 2290 1 0 {name=R64
W=5.73
L=5.92
model=res_xhigh_po_5p73
spiceprefix=X
mult=1}
C {gnd.sym} -270 2240 0 0 {name=l228 lab=GND}
C {lab_pin.sym} -160 2290 1 1 {name=l229 sig_type=std_logic lab=vcm52}
C {lab_pin.sym} -290 2290 0 0 {name=l230 sig_type=std_logic lab=vout5p}
C {lab_pin.sym} 10 2290 0 0 {name=l231 sig_type=std_logic lab=vout5n}
C {vsource.sym} -1740 -110 0 0 {name=V22 value="DC 1.25 AC 1 SIN(1.25 0.0004 1000MEG)"}
C {vsource.sym} -500 -110 0 0 {name=V4 value="DC 1.25 AC -1 SIN(1.25 -0.0004 1000MEG)"}
C {code.sym} -1890 -650 0 0 {name=TT_MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {code_shown.sym} -2260 -640 0 0 {name=s2 only_toplevel=false value=
"
.control
 set wr_vecnames
 set wr_singlescale

 let mc_runs = 1 
 let run = 1
 dowhile run <= mc_runs
  dc V4 1.25 1.251 0.0001
  *tran 0.01ns 10ns
  *ac dec 30 10 30000000000 
  options savecurrents
  save all
  plot vout5p-vout5n
  
  reset
  let run = run + 1
 end
.endc

"}
C {sky130_fd_pr/res_high_po_0p35.sym} -810 -1680 0 0 {name=R33
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -830 -1670 0 0 {name=l233 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} -810 -1190 0 0 {name=R34
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -830 -1180 0 0 {name=l234 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} 680 -1680 0 0 {name=R41
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} 660 -1670 0 0 {name=l235 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} 680 -1190 0 0 {name=R42
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} 660 -1180 0 0 {name=l236 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} -1980 1680 0 0 {name=R47
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -2000 1690 0 0 {name=l237 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} -1980 2170 0 0 {name=R48
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -2000 2180 0 0 {name=l238 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} -570 1700 0 0 {name=R53
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -590 1710 0 0 {name=l239 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} -570 2190 0 0 {name=R54
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} -590 2200 0 0 {name=l240 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} 810 1670 0 0 {name=R59
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} 790 1680 0 0 {name=l241 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} 810 2160 0 0 {name=R60
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {gnd.sym} 790 2170 0 0 {name=l242 lab=GND}
C {lab_pin.sym} -1470 -1850 0 0 {name=l232 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1470 -1370 0 0 {name=l150 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1210 -1560 1 1 {name=l243 sig_type=std_logic lab=vbias2}
C {gnd.sym} -1370 -970 0 0 {name=l152 lab=GND}
C {lab_pin.sym} -1290 -1080 1 1 {name=l244 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} 20 -1850 0 0 {name=l245 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 20 -1370 0 0 {name=l246 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 270 -1560 1 1 {name=l143 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} 310 -1080 1 1 {name=l165 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} -1520 -730 0 0 {name=l247 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -230 -750 0 0 {name=l7 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -2690 330 0 0 {name=l23 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1520 320 0 0 {name=l47 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -260 340 0 0 {name=l64 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1100 340 0 0 {name=l87 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -2370 1800 1 1 {name=l254 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} -2640 1510 0 0 {name=l255 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -2640 1990 0 0 {name=l178 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -2460 2280 1 1 {name=l183 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} -1230 1530 0 0 {name=l123 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1050 1820 1 1 {name=l196 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} -1230 2010 0 0 {name=l201 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1050 2300 1 1 {name=l248 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} 150 1500 0 0 {name=l214 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 330 1790 1 1 {name=l249 sig_type=std_logic lab=vbias2}
C {lab_pin.sym} 150 1980 0 0 {name=l219 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 330 2270 1 1 {name=l250 sig_type=std_logic lab=vbias2}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2320 10 0 0 {name=M53
L=0.15
W=1.28
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2300 80 0 0 {name=l251 lab=GND}
C {lab_pin.sym} -2400 -20 0 0 {name=l252 sig_type=std_logic lab=vgs9
}
C {isource.sym} -2300 -110 0 0 {name=I1 value=40u}
C {lab_pin.sym} -2300 -190 0 0 {name=l253 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/res_high_po_0p35.sym} 2550 1160 0 0 {name=R31
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2780 1160 0 0 {name=R32
W=0.35
L=4
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -2560 30 0 0 {name=M61
L=0.15
W=0.64
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {gnd.sym} -2540 100 0 0 {name=l82 lab=GND}
C {lab_pin.sym} -2640 0 0 0 {name=l106 sig_type=std_logic lab=vgs8
}
C {isource.sym} -2540 -90 0 0 {name=I2 value=40u}
C {lab_pin.sym} -2540 -170 0 0 {name=l256 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/cap_mim_m3_1.sym} -760 -1120 0 0 {name=C4 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 730 -1600 0 0 {name=C5 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 730 -1120 0 0 {name=C6 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1930 1760 0 0 {name=C13 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1930 2240 0 0 {name=C7 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -520 1780 0 0 {name=C8 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -520 2260 0 0 {name=C9 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 860 1750 0 0 {name=C10 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 860 2230 0 0 {name=C11 model=cap_mim_m3_1 W=25 L=25 MF=4 spiceprefix=X}
C {lab_pin.sym} 1480 70 0 0 {name=l257 sig_type=std_logic lab=vsoc}
