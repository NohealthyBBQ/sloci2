v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 3220 -2250 3220 -2190 {
lab=Vpixel_out}
N 3220 -2050 3220 -2020 {
lab=Vcurr_mid2}
N 3220 -1960 3220 -1920 {
lab=VSS}
N 3120 -1990 3180 -1990 {
lab=Vb0}
N 3120 -2080 3180 -2080 {
lab=Vb1}
N 3220 -2210 3320 -2210 {
lab=Vpixel_out}
N 3220 -2130 3220 -2110 {
lab=#net1}
N 3220 -1990 3270 -1990 {
lab=VSS}
N 3270 -1990 3270 -1940 {
lab=VSS}
N 3220 -1940 3270 -1940 {
lab=VSS}
N 3270 -2080 3270 -1990 {
lab=VSS}
N 3220 -2080 3270 -2080 {
lab=VSS}
N 3320 -2210 3350 -2210 {
lab=Vpixel_out}
N 2840 -2730 2970 -2730 {
lab=Vpixel_out}
N 3220 -2390 3220 -2250 {
lab=Vpixel_out}
N 2770 -2830 2770 -2790 {
lab=VDD}
N 2770 -2590 2770 -2550 {
lab=VSS}
N 2610 -2730 2690 -2730 {
lab=Vin_1}
N 2650 -2750 2690 -2750 {
lab=rst_b_clk}
N 2650 -2710 2690 -2710 {
lab=D1}
N 3350 -2170 3350 -2060 {
lab=Vbuff_out}
N 3350 -2060 3600 -2060 {
lab=Vbuff_out}
N 3600 -2190 3600 -2060 {
lab=Vbuff_out}
N 3520 -2190 3600 -2190 {
lab=Vbuff_out}
N 3790 -2190 3790 -2120 {
lab=Vcap}
N 3790 -2120 3900 -2120 {
lab=Vcap}
N 3900 -2190 3900 -2120 {
lab=Vcap}
N 3990 -2290 3990 -2220 {
lab=Vout}
N 3990 -2160 3990 -2090 {
lab=VSS}
N 3600 -2190 3640 -2190 {
lab=Vbuff_out}
N 3670 -2190 3670 -2160 {
lab=VSS}
N 3840 -2190 3840 -2160 {
lab=VSS}
N 3790 -2120 3790 -2080 {
lab=Vcap}
N 3990 -2190 4070 -2190 {
lab=VDD}
N 3670 -2260 3670 -2230 {
lab=sh_clk}
N 3540 -2390 3570 -2390 {
lab=sh_clk}
N 3730 -2390 3760 -2390 {
lab=sh_clk_b}
N 3840 -2260 3840 -2230 {
lab=sh_clk_b}
N 3700 -2190 3790 -2190 {
lab=Vcap}
N 3900 -2190 3950 -2190 {
lab=Vcap}
N 3790 -2190 3810 -2190 {
lab=Vcap}
N 3870 -2190 3900 -2190 {
lab=Vcap}
N 3910 -2380 3950 -2380 {
lab=Vb2}
N 3990 -2380 4030 -2380 {
lab=VDD}
N 4030 -2410 4030 -2380 {
lab=VDD}
N 3990 -2410 4030 -2410 {
lab=VDD}
N 2840 -2400 2970 -2400 {
lab=Vpixel_out}
N 2770 -2500 2770 -2460 {
lab=VDD}
N 2770 -2260 2770 -2220 {
lab=VSS}
N 2610 -2400 2690 -2400 {
lab=Vin_2}
N 2650 -2420 2690 -2420 {
lab=rst_b_clk}
N 2650 -2380 2690 -2380 {
lab=D2}
N 2840 -2070 2970 -2070 {
lab=Vpixel_out}
N 2770 -2170 2770 -2130 {
lab=VDD}
N 2770 -1930 2770 -1890 {
lab=VSS}
N 2610 -2070 2690 -2070 {
lab=Vin_3}
N 2650 -2090 2690 -2090 {
lab=rst_b_clk}
N 2650 -2050 2690 -2050 {
lab=D3}
N 2460 -2740 2460 -2730 {
lab=Vin_1}
N 2460 -2730 2610 -2730 {
lab=Vin_1}
N 2460 -2430 2460 -2400 {
lab=Vin_2}
N 2460 -2400 2610 -2400 {
lab=Vin_2}
N 2460 -2100 2460 -2070 {
lab=Vin_3}
N 2460 -2070 2610 -2070 {
lab=Vin_3}
N 2970 -2400 3220 -2400 {
lab=Vpixel_out}
N 2970 -2070 3040 -2070 {
lab=Vpixel_out}
N 3040 -2400 3040 -2070 {
lab=Vpixel_out}
N 3040 -2730 3040 -2400 {
lab=Vpixel_out}
N 2970 -2730 3040 -2730 {
lab=Vpixel_out}
N 3220 -2400 3220 -2390 {
lab=Vpixel_out}
N 3270 -2700 3330 -2700 {
lab=A}
N 3270 -2640 3330 -2640 {
lab=B}
N 3420 -2320 3420 -2270 {
lab=Vbias}
N 4160 -2070 4210 -2070 {
lab=Vb1}
N 4160 -1980 4210 -1980 {
lab=Vb0}
N 4250 -1950 4250 -1900 {
lab=VSS}
N 4250 -1980 4290 -1980 {
lab=VSS}
N 4290 -1980 4290 -1900 {
lab=VSS}
N 4250 -1900 4290 -1900 {
lab=VSS}
N 4290 -2070 4290 -1980 {
lab=VSS}
N 4250 -2070 4290 -2070 {
lab=VSS}
N 4250 -2320 4250 -2310 {
lab=VDD}
N 4250 -2190 4350 -2190 {
lab=Vb2}
N 4350 -2280 4350 -2190 {
lab=Vb2}
N 4290 -2280 4350 -2280 {
lab=Vb2}
N 4250 -2040 4250 -2010 {
lab=Vcurr_mid}
N 4210 -2280 4250 -2280 {
lab=VDD}
N 4210 -2320 4210 -2280 {
lab=VDD}
N 4210 -2320 4250 -2320 {
lab=VDD}
N 4130 -2070 4160 -2070 {
lab=Vb1}
N 4130 -1980 4160 -1980 {
lab=Vb0}
N 3640 -2480 3640 -2450 {
lab=VDD}
N 3990 -2450 3990 -2410 {
lab=VDD}
N 3430 -2790 3430 -2760 {
lab=VDD}
N 3990 -2260 4030 -2260 {
lab=Vout}
N 4250 -2190 4250 -2170 {
lab=Vb2}
N 4250 -2250 4250 -2190 {
lab=Vb2}
N 4250 -2110 4250 -2100 {
lab=#net2}
N 4470 -2030 4510 -2030 {
lab=VSS}
N 4470 -2030 4470 -1960 {
lab=VSS}
N 4470 -1960 4550 -1960 {
lab=VSS}
N 4550 -2000 4550 -1960 {
lab=VSS}
N 4550 -1960 4580 -1960 {
lab=VSS}
N 4580 -2030 4580 -1960 {
lab=VSS}
N 4550 -2030 4580 -2030 {
lab=VSS}
N 4550 -2080 4550 -2060 {
lab=Vcurr_mid}
N 4550 -2230 4550 -2200 {
lab=VDD}
N 4500 -2200 4550 -2200 {
lab=VDD}
N 4500 -2260 4500 -2200 {
lab=VDD}
N 4500 -2260 4550 -2260 {
lab=VDD}
N 4500 -2340 4500 -2260 {
lab=VDD}
N 4500 -2340 4550 -2340 {
lab=VDD}
N 4550 -2340 4550 -2290 {
lab=VDD}
N 4590 -2260 4630 -2260 {
lab=VDD}
N 4630 -2340 4630 -2260 {
lab=VDD}
N 4550 -2340 4630 -2340 {
lab=VDD}
N 4690 -2030 4730 -2030 {
lab=VSS}
N 4690 -2030 4690 -1960 {
lab=VSS}
N 4690 -1960 4770 -1960 {
lab=VSS}
N 4770 -2000 4770 -1960 {
lab=VSS}
N 4770 -1960 4800 -1960 {
lab=VSS}
N 4800 -2030 4800 -1960 {
lab=VSS}
N 4770 -2030 4800 -2030 {
lab=VSS}
N 4770 -2080 4770 -2060 {
lab=Vcurr_mid2}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 3200 -2080 0 0 {name=M4
L=2
W=9
nf=9
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 3200 -1990 0 0 {name=M5
L=2
W=9
nf=9
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 3130 -2080 0 0 {name=l1 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 3130 -1990 0 0 {name=l2 sig_type=std_logic lab=Vb0}
C {devices/ammeter.sym} 3220 -2160 0 0 {name=Vm1 current=40e-6}
C {cmos_imager/3T.sym} 2650 -2710 0 0 {name=X1}
C {lab_wire.sym} 2770 -2820 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {ip_block/opamp/miller_2stage/miller_2stage.sym} 3450 -2190 0 0 {name=x2}
C {devices/vdd.sym} 3450 -2270 0 0 {name=l9 lab=VDD}
C {lab_wire.sym} 3580 -2190 0 0 {name=l3 sig_type=std_logic lab=Vbuff_out}
C {lab_wire.sym} 3290 -2210 0 0 {name=l3 sig_type=std_logic lab=Vpixel_out}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 3670 -2210 3 1 {name=M8
L=0.5
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 3840 -2210 3 1 {name=M14
L=0.5
W=2.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3790 -2050 0 0 {name=C2 model=cap_mim_m3_1 W=20 L=20 MF=1 spiceprefix=X}
C {lab_wire.sym} 4060 -2190 0 1 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3670 -2260 0 1 {name=l23 lab=sh_clk}
C {ip_block/logic_gate/inv.sym} 810 910 0 0 {name=X3}
C {devices/lab_pin.sym} 3760 -2390 0 1 {name=l23 lab=sh_clk_b}
C {devices/lab_pin.sym} 3840 -2260 0 1 {name=l23 lab=sh_clk_b}
C {lab_wire.sym} 3790 -2140 0 0 {name=l4 sig_type=std_logic lab=Vcap}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3970 -2190 0 0 {name=M15
L=0.5
W=8
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3970 -2380 0 0 {name=M19
L=2
W=16
nf=1
mult=8
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 3910 -2380 0 0 {name=l4 sig_type=std_logic lab=Vb2}
C {devices/ammeter.sym} 3990 -2320 0 0 {name=Vm2 current=40e-6}
C {cmos_imager/3T.sym} 2650 -2380 0 0 {name=X4}
C {lab_wire.sym} 2770 -2490 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2670 -2420 0 0 {name=l23 lab=rst_b_clk}
C {cmos_imager/3T.sym} 2650 -2050 0 0 {name=X5}
C {lab_wire.sym} 2770 -2160 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2670 -2090 0 0 {name=l23 lab=rst_b_clk}
C {lab_wire.sym} 2530 -2730 0 0 {name=l4 sig_type=std_logic lab=Vin_1}
C {lab_wire.sym} 2530 -2400 0 0 {name=l4 sig_type=std_logic lab=Vin_2}
C {lab_wire.sym} 2520 -2070 0 0 {name=l4 sig_type=std_logic lab=Vin_3}
C {ip_block/logic_gate/2_to_4_decoder.sym} 580 590 0 0 {name=X9}
C {lab_wire.sym} 2650 -2710 0 0 {name=l4 sig_type=std_logic lab=D1}
C {lab_wire.sym} 2650 -2380 0 0 {name=l4 sig_type=std_logic lab=D2}
C {lab_wire.sym} 2650 -2050 0 0 {name=l4 sig_type=std_logic lab=D3}
C {lab_wire.sym} 3530 -2680 0 1 {name=l4 sig_type=std_logic lab=D1}
C {lab_wire.sym} 3530 -2660 0 1 {name=l4 sig_type=std_logic lab=D2}
C {lab_wire.sym} 3530 -2640 0 1 {name=l4 sig_type=std_logic lab=D3}
C {noconn.sym} 3530 -2700 0 1 {name=l4}
C {devices/ipin.sym} 3540 -2390 0 0 {name=p3 lab=sh_clk}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4230 -2070 0 0 {name=M1
L=2
W=9
nf=9
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4230 -1980 0 0 {name=M2
L=2
W=9
nf=9
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 4270 -2280 0 1 {name=M3
L=2
W=16
nf=1
mult=8
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 4350 -2190 0 1 {name=l1 sig_type=std_logic lab=Vb2}
C {devices/iopin.sym} 4210 -2320 0 1 {name=p1 lab=VDD}
C {devices/iopin.sym} 4250 -1900 0 1 {name=p2 lab=VSS}
C {devices/ipin.sym} 4130 -2070 0 0 {name=p3 lab=Vb1}
C {devices/ipin.sym} 4130 -1980 0 0 {name=p4 lab=Vb0}
C {lab_wire.sym} 3640 -2480 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3990 -2450 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3220 -1920 0 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 3790 -2020 3 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 3990 -2090 3 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 3640 -2330 3 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 2770 -1890 0 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 2770 -2220 0 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 2770 -2550 0 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 2320 -2610 1 1 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 2320 -2300 1 1 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 2320 -1970 1 1 {name=l23 lab=VSS}
C {devices/ipin.sym} 3420 -2320 0 0 {name=p3 lab=Vbias}
C {devices/ipin.sym} 3270 -2700 0 0 {name=p3 lab=A}
C {devices/ipin.sym} 3270 -2640 0 0 {name=p4 lab=B}
C {lab_wire.sym} 3430 -2790 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3430 -2550 3 0 {name=l23 lab=VSS}
C {opin.sym} 4030 -2260 0 0 {name=p1 lab=Vout}
C {devices/ipin.sym} 2650 -2750 0 0 {name=p3 lab=rst_b_clk}
C {devices/ammeter.sym} 4250 -2140 0 0 {name=Vm3 current=40e-6}
C {cmos_imager/photodiode_real_rc_4cap_lvs.sym} -460 630 0 0 {name=X6}
C {cmos_imager/photodiode_real_rc_6cap_lvs.sym} -460 940 0 0 {name=X7}
C {cmos_imager/photodiode_real_rc_8cap_lvs.sym} -460 1270 0 0 {name=X8}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4530 -2030 0 0 {name=M6
L=2
W=4
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 4250 -2020 0 0 {name=l1 sig_type=std_logic lab=Vcurr_mid}
C {devices/lab_pin.sym} 4550 -1960 3 0 {name=l23 lab=VSS}
C {lab_wire.sym} 4550 -2080 0 0 {name=l1 sig_type=std_logic lab=Vcurr_mid}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 4570 -2260 0 1 {name=M7
L=2
W=16
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 4500 -2340 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3220 -2030 0 0 {name=l1 sig_type=std_logic lab=Vcurr_mid2}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4750 -2030 0 0 {name=M9
L=2
W=4
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 4770 -1960 3 0 {name=l23 lab=VSS}
C {lab_wire.sym} 4770 -2080 0 0 {name=l1 sig_type=std_logic lab=Vcurr_mid2}
C {devices/lab_pin.sym} 3450 -2130 3 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 3670 -2160 3 0 {name=l23 lab=VSS}
C {devices/lab_pin.sym} 3840 -2160 3 0 {name=l23 lab=VSS}
