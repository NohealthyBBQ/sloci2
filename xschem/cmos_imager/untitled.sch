** sch_path: xschem/cmos_imager/untitled.sch
**.subckt untitled
XD1 GND net1 sky130_fd_pr__diode_pw2nd_05v5 area=1e12 pj=4e6
V1 net1 GND 3
**.ends
.GLOBAL GND
.end
