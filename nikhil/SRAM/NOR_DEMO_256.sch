v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 160 67470 160 67570 {
lab=BL_SEL}
N 220 67470 220 67570 {
lab=BLB_SEL}
N 190 67470 190 67480 {
lab=VDD}
N 190 67550 190 67570 {
lab=GND}
N 40 -20 40 130 {
lab=BL_SEL}
N 40 130 40 280 {
lab=BL_SEL}
N 40 280 40 470 {
lab=BL_SEL}
N 340 -20 340 130 {
lab=BLB_SEL}
N 340 130 340 280 {
lab=BLB_SEL}
N 340 280 340 480 {
lab=BLB_SEL}
N 40 -60 40 -20 {
lab=BL_SEL}
N 340 -60 340 -20 {
lab=BLB_SEL}
N 40 -240 40 -60 {
lab=BL_SEL}
N 340 -240 340 -60 {
lab=BLB_SEL}
N -50 -350 200 -350 {
lab=WLB_A}
N 180 -330 180 -310 {
lab=WL_A}
N -50 -330 180 -330 {
lab=WL_A}
N -20 -100 200 -100 {
lab=WLB_B}
N 180 -80 180 -70 {
lab=WL_B}
N -20 -80 180 -80 {
lab=WL_B}
N -30 110 200 110 {
lab=WLB_D}
N 180 130 180 140 {
lab=WL_D}
N 70 130 180 130 {
lab=WL_D}
N -70 70 40 70 {
lab=BL_SEL}
N 340 70 450 70 {
lab=BLB_SEL}
N -700 -140 -700 -120 {
lab=GND}
N -700 -230 -700 -200 {
lab=VDD}
N -510 -340 -510 -240 {
lab=BL}
N -450 -340 -450 -240 {
lab=BL_SEL}
N -480 -340 -480 -330 {
lab=VDD}
N -480 -260 -480 -240 {
lab=GND}
N 190 67610 190 67630 {
lab=SELB}
N 190 67410 190 67430 {
lab=SEL}
N -560 -280 -510 -280 {
lab=BL}
N -450 -280 -410 -280 {
lab=BL_SEL}
N -510 -10 -510 90 {
lab=BLB}
N -450 -10 -450 90 {
lab=BLB_SEL}
N -480 -10 -480 0 {
lab=VDD}
N -480 70 -480 90 {
lab=GND}
N -560 50 -510 50 {
lab=BLB}
N -450 50 -410 50 {
lab=BLB_SEL}
N -1140 290 -1140 310 {
lab=GND}
N -870 290 -870 310 {
lab=GND}
N -1700 520 -1700 560 {
lab=WL_A}
N -1700 620 -1700 660 {
lab=GND}
N -1470 500 -1470 560 {
lab=WLB_A}
N -1470 620 -1470 660 {
lab=GND}
N -1210 520 -1210 560 {
lab=WL_B}
N -1210 620 -1210 660 {
lab=GND}
N -980 500 -980 560 {
lab=WLB_B}
N -980 620 -980 660 {
lab=GND}
N -740 520 -740 560 {
lab=WLB_D}
N -740 620 -740 660 {
lab=GND}
N -510 500 -510 560 {
lab=WL_D}
N -510 620 -510 660 {
lab=GND}
N -1090 980 -1090 1000 {
lab=GND}
N -820 980 -820 1000 {
lab=GND}
N -480 130 -480 150 {
lab=SEL}
N -480 -200 -480 -180 {
lab=SEL}
N -480 -400 -480 -380 {
lab=SELB}
N -480 -70 -480 -50 {
lab=SELB}
N 220 -350 220 -310 {
lab=WLB_A}
N 200 -350 220 -350 {
lab=WLB_A}
N 220 110 220 140 {
lab=WLB_D}
N 200 110 220 110 {
lab=WLB_D}
N 220 -100 220 -70 {
lab=WLB_B}
N 200 -100 220 -100 {
lab=WLB_B}
N -480 -330 -400 -330 {
lab=VDD}
N -480 -260 -390 -260 {
lab=GND}
N -480 -0 -390 -0 {
lab=VDD}
N -480 70 -400 70 {
lab=GND}
N 190 67480 260 67480 {
lab=VDD}
N 190 67550 260 67550 {
lab=GND}
N 220 -190 220 -150 {
lab=VDD}
N 220 50 220 70 {
lab=VDD}
N 220 260 220 290 {
lab=VDD}
N 180 260 180 290 {
lab=GND}
N 180 50 180 70 {
lab=GND}
N 180 -190 180 -160 {
lab=GND}
N -30 340 200 340 {
lab=WLB_C}
N 180 360 180 370 {
lab=WL_C}
N 70 360 180 360 {
lab=WL_C}
N 220 340 220 370 {
lab=WLB_C}
N 200 340 220 340 {
lab=WLB_C}
N 180 490 180 520 {
lab=GND}
N 40 470 40 1280 {
lab=BL_SEL}
N 340 480 340 1290 {
lab=BLB_SEL}
N -30 550 200 550 {
lab=WLB_C}
N 180 570 180 580 {
lab=WL_C}
N 70 570 180 570 {
lab=WL_C}
N 220 550 220 580 {
lab=WLB_C}
N 200 550 220 550 {
lab=WLB_C}
N 220 700 220 730 {
lab=VDD}
N 180 700 180 730 {
lab=GND}
N -30 770 200 770 {
lab=WLB_C}
N 180 790 180 800 {
lab=WL_C}
N 70 790 180 790 {
lab=WL_C}
N 220 770 220 800 {
lab=WLB_C}
N 200 770 220 770 {
lab=WLB_C}
N 220 920 220 950 {
lab=VDD}
N 180 920 180 950 {
lab=GND}
N -30 1040 200 1040 {
lab=WLB_C}
N 180 1060 180 1070 {
lab=WL_C}
N 70 1060 180 1060 {
lab=WL_C}
N 220 1040 220 1070 {
lab=WLB_C}
N 200 1040 220 1040 {
lab=WLB_C}
N 220 1190 220 1220 {
lab=VDD}
N 180 1190 180 1220 {
lab=GND}
N 40 1280 40 2020 {
lab=BL_SEL}
N 340 1290 340 2020 {
lab=BLB_SEL}
N -30 1300 200 1300 {
lab=WLB_C}
N 180 1320 180 1330 {
lab=WL_C}
N 70 1320 180 1320 {
lab=WL_C}
N 220 1300 220 1330 {
lab=WLB_C}
N 200 1300 220 1300 {
lab=WLB_C}
N 220 1450 220 1480 {
lab=VDD}
N 180 1450 180 1480 {
lab=GND}
N -30 1520 200 1520 {
lab=WLB_C}
N 180 1540 180 1550 {
lab=WL_C}
N 70 1540 180 1540 {
lab=WL_C}
N 220 1520 220 1550 {
lab=WLB_C}
N 200 1520 220 1520 {
lab=WLB_C}
N 220 1670 220 1700 {
lab=VDD}
N 180 1670 180 1700 {
lab=GND}
N -30 1750 200 1750 {
lab=WLB_C}
N 180 1770 180 1780 {
lab=WL_C}
N 70 1770 180 1770 {
lab=WL_C}
N 220 1750 220 1780 {
lab=WLB_C}
N 200 1750 220 1750 {
lab=WLB_C}
N 220 1900 220 1930 {
lab=VDD}
N 180 1900 180 1930 {
lab=GND}
N 40 2020 40 3050 {
lab=BL_SEL}
N 340 2020 340 3080 {
lab=BLB_SEL}
N -30 2010 200 2010 {
lab=WLB_C}
N 180 2030 180 2040 {
lab=WL_C}
N 70 2030 180 2030 {
lab=WL_C}
N 220 2010 220 2040 {
lab=WLB_C}
N 200 2010 220 2010 {
lab=WLB_C}
N 220 2160 220 2190 {
lab=VDD}
N 180 2160 180 2190 {
lab=GND}
N -30 2270 200 2270 {
lab=WLB_C}
N 180 2290 180 2300 {
lab=WL_C}
N 70 2290 180 2290 {
lab=WL_C}
N 220 2270 220 2300 {
lab=WLB_C}
N 200 2270 220 2270 {
lab=WLB_C}
N 220 2420 220 2450 {
lab=VDD}
N 180 2420 180 2450 {
lab=GND}
N -30 2490 200 2490 {
lab=WLB_C}
N 180 2510 180 2520 {
lab=WL_C}
N 70 2510 180 2510 {
lab=WL_C}
N 220 2490 220 2520 {
lab=WLB_C}
N 200 2490 220 2490 {
lab=WLB_C}
N 220 2640 220 2670 {
lab=VDD}
N 180 2640 180 2670 {
lab=GND}
N -30 2720 200 2720 {
lab=WLB_C}
N 180 2740 180 2750 {
lab=WL_C}
N 70 2740 180 2740 {
lab=WL_C}
N 220 2720 220 2750 {
lab=WLB_C}
N 200 2720 220 2720 {
lab=WLB_C}
N 220 2870 220 2900 {
lab=VDD}
N 180 2870 180 2900 {
lab=GND}
N 40 3050 40 4590 {
lab=BL_SEL}
N 340 3070 340 4580 {
lab=BLB_SEL}
N 340 4570 340 6790 {
lab=BLB_SEL}
N -30 3180 200 3180 {
lab=WLB_C}
N 180 3200 180 3210 {
lab=WL_C}
N 70 3200 180 3200 {
lab=WL_C}
N 220 3180 220 3210 {
lab=WLB_C}
N 200 3180 220 3180 {
lab=WLB_C}
N 220 3330 220 3360 {
lab=VDD}
N 180 3330 180 3360 {
lab=GND}
N -30 3440 200 3440 {
lab=WLB_C}
N 180 3460 180 3470 {
lab=WL_C}
N 70 3460 180 3460 {
lab=WL_C}
N 220 3440 220 3470 {
lab=WLB_C}
N 200 3440 220 3440 {
lab=WLB_C}
N 220 3590 220 3620 {
lab=VDD}
N 180 3590 180 3620 {
lab=GND}
N -30 3660 200 3660 {
lab=WLB_C}
N 180 3680 180 3690 {
lab=WL_C}
N 70 3680 180 3680 {
lab=WL_C}
N 220 3660 220 3690 {
lab=WLB_C}
N 200 3660 220 3660 {
lab=WLB_C}
N 220 3810 220 3840 {
lab=VDD}
N 180 3810 180 3840 {
lab=GND}
N -30 3890 200 3890 {
lab=WLB_C}
N 180 3910 180 3920 {
lab=WL_C}
N 70 3910 180 3910 {
lab=WL_C}
N 220 3890 220 3920 {
lab=WLB_C}
N 200 3890 220 3890 {
lab=WLB_C}
N 220 4040 220 4070 {
lab=VDD}
N 180 4040 180 4070 {
lab=GND}
N -30 4150 200 4150 {
lab=WLB_C}
N 180 4170 180 4180 {
lab=WL_C}
N 70 4170 180 4170 {
lab=WL_C}
N 220 4150 220 4180 {
lab=WLB_C}
N 200 4150 220 4150 {
lab=WLB_C}
N 220 4300 220 4330 {
lab=VDD}
N 180 4300 180 4330 {
lab=GND}
N -30 4410 200 4410 {
lab=WLB_C}
N 180 4430 180 4440 {
lab=WL_C}
N 70 4430 180 4430 {
lab=WL_C}
N 220 4410 220 4440 {
lab=WLB_C}
N 200 4410 220 4410 {
lab=WLB_C}
N 220 4560 220 4590 {
lab=VDD}
N 180 4560 180 4590 {
lab=GND}
N -30 4630 200 4630 {
lab=WLB_C}
N 180 4650 180 4660 {
lab=WL_C}
N 70 4650 180 4650 {
lab=WL_C}
N 220 4630 220 4660 {
lab=WLB_C}
N 200 4630 220 4630 {
lab=WLB_C}
N 220 4780 220 4810 {
lab=VDD}
N 180 4780 180 4810 {
lab=GND}
N -30 4860 200 4860 {
lab=WLB_C}
N 180 4880 180 4890 {
lab=WL_C}
N 70 4880 180 4880 {
lab=WL_C}
N 220 4860 220 4890 {
lab=WLB_C}
N 200 4860 220 4860 {
lab=WLB_C}
N 220 5010 220 5040 {
lab=VDD}
N 180 5010 180 5040 {
lab=GND}
N 340 6790 340 6810 {
lab=BLB_SEL}
N -30 5100 200 5100 {
lab=WLB_C}
N 180 5120 180 5130 {
lab=WL_C}
N 70 5120 180 5120 {
lab=WL_C}
N 220 5100 220 5130 {
lab=WLB_C}
N 200 5100 220 5100 {
lab=WLB_C}
N 220 5250 220 5280 {
lab=VDD}
N 180 5250 180 5280 {
lab=GND}
N -30 5360 200 5360 {
lab=WLB_C}
N 180 5380 180 5390 {
lab=WL_C}
N 70 5380 180 5380 {
lab=WL_C}
N 220 5360 220 5390 {
lab=WLB_C}
N 200 5360 220 5360 {
lab=WLB_C}
N 220 5510 220 5540 {
lab=VDD}
N 180 5510 180 5540 {
lab=GND}
N -30 5580 200 5580 {
lab=WLB_C}
N 180 5600 180 5610 {
lab=WL_C}
N 70 5600 180 5600 {
lab=WL_C}
N 220 5580 220 5610 {
lab=WLB_C}
N 200 5580 220 5580 {
lab=WLB_C}
N 220 5730 220 5760 {
lab=VDD}
N 180 5730 180 5760 {
lab=GND}
N -30 5810 200 5810 {
lab=WLB_C}
N 180 5830 180 5840 {
lab=WL_C}
N 70 5830 180 5830 {
lab=WL_C}
N 220 5810 220 5840 {
lab=WLB_C}
N 200 5810 220 5810 {
lab=WLB_C}
N 220 5960 220 5990 {
lab=VDD}
N 180 5960 180 5990 {
lab=GND}
N -30 6070 200 6070 {
lab=WLB_C}
N 180 6090 180 6100 {
lab=WL_C}
N 70 6090 180 6090 {
lab=WL_C}
N 220 6070 220 6100 {
lab=WLB_C}
N 200 6070 220 6070 {
lab=WLB_C}
N 220 6220 220 6250 {
lab=VDD}
N 180 6220 180 6250 {
lab=GND}
N -30 6330 200 6330 {
lab=WLB_C}
N 180 6350 180 6360 {
lab=WL_C}
N 70 6350 180 6350 {
lab=WL_C}
N 220 6330 220 6360 {
lab=WLB_C}
N 200 6330 220 6330 {
lab=WLB_C}
N 220 6480 220 6510 {
lab=VDD}
N 180 6480 180 6510 {
lab=GND}
N -30 6550 200 6550 {
lab=WLB_C}
N 180 6570 180 6580 {
lab=WL_C}
N 70 6570 180 6570 {
lab=WL_C}
N 220 6550 220 6580 {
lab=WLB_C}
N 200 6550 220 6550 {
lab=WLB_C}
N 220 6700 220 6730 {
lab=VDD}
N 180 6700 180 6730 {
lab=GND}
N -30 6780 200 6780 {
lab=WLB_C}
N 180 6800 180 6810 {
lab=WL_C}
N 70 6800 180 6800 {
lab=WL_C}
N 220 6780 220 6810 {
lab=WLB_C}
N 200 6780 220 6780 {
lab=WLB_C}
N 180 6930 180 6960 {
lab=GND}
N 40 4590 40 4730 {
lab=BL_SEL}
N 40 4730 40 5680 {
lab=BL_SEL}
N 40 5670 40 6880 {
lab=BL_SEL}
N 340 6810 340 6880 {
lab=BLB_SEL}
N -30 6950 200 6950 {
lab=WLB_C}
N 180 6970 180 6980 {
lab=WL_C}
N 70 6970 180 6970 {
lab=WL_C}
N 220 6950 220 6980 {
lab=WLB_C}
N 200 6950 220 6950 {
lab=WLB_C}
N 220 7100 220 7130 {
lab=VDD}
N 180 7100 180 7130 {
lab=GND}
N -30 7210 200 7210 {
lab=WLB_C}
N 180 7230 180 7240 {
lab=WL_C}
N 70 7230 180 7230 {
lab=WL_C}
N 220 7210 220 7240 {
lab=WLB_C}
N 200 7210 220 7210 {
lab=WLB_C}
N 220 7360 220 7390 {
lab=VDD}
N 180 7360 180 7390 {
lab=GND}
N -30 7430 200 7430 {
lab=WLB_C}
N 180 7450 180 7460 {
lab=WL_C}
N 70 7450 180 7450 {
lab=WL_C}
N 220 7430 220 7460 {
lab=WLB_C}
N 200 7430 220 7430 {
lab=WLB_C}
N 220 7580 220 7610 {
lab=VDD}
N 180 7580 180 7610 {
lab=GND}
N -30 7660 200 7660 {
lab=WLB_C}
N 180 7680 180 7690 {
lab=WL_C}
N 70 7680 180 7680 {
lab=WL_C}
N 220 7660 220 7690 {
lab=WLB_C}
N 200 7660 220 7660 {
lab=WLB_C}
N 220 7810 220 7840 {
lab=VDD}
N 180 7810 180 7840 {
lab=GND}
N -30 7920 200 7920 {
lab=WLB_C}
N 180 7940 180 7950 {
lab=WL_C}
N 70 7940 180 7940 {
lab=WL_C}
N 220 7920 220 7950 {
lab=WLB_C}
N 200 7920 220 7920 {
lab=WLB_C}
N 220 8070 220 8100 {
lab=VDD}
N 180 8070 180 8100 {
lab=GND}
N -30 8180 200 8180 {
lab=WLB_C}
N 180 8200 180 8210 {
lab=WL_C}
N 70 8200 180 8200 {
lab=WL_C}
N 220 8180 220 8210 {
lab=WLB_C}
N 200 8180 220 8180 {
lab=WLB_C}
N 220 8330 220 8360 {
lab=VDD}
N 180 8330 180 8360 {
lab=GND}
N -30 8400 200 8400 {
lab=WLB_C}
N 180 8420 180 8430 {
lab=WL_C}
N 70 8420 180 8420 {
lab=WL_C}
N 220 8400 220 8430 {
lab=WLB_C}
N 200 8400 220 8400 {
lab=WLB_C}
N 220 8550 220 8580 {
lab=VDD}
N 180 8550 180 8580 {
lab=GND}
N -30 8630 200 8630 {
lab=WLB_C}
N 180 8650 180 8660 {
lab=WL_C}
N 70 8650 180 8650 {
lab=WL_C}
N 220 8630 220 8660 {
lab=WLB_C}
N 200 8630 220 8630 {
lab=WLB_C}
N 220 8780 220 8810 {
lab=VDD}
N 180 8780 180 8810 {
lab=GND}
N -30 8870 200 8870 {
lab=WLB_C}
N 180 8890 180 8900 {
lab=WL_C}
N 70 8890 180 8890 {
lab=WL_C}
N 220 8870 220 8900 {
lab=WLB_C}
N 200 8870 220 8870 {
lab=WLB_C}
N 220 9020 220 9050 {
lab=VDD}
N 180 9020 180 9050 {
lab=GND}
N -30 9130 200 9130 {
lab=WLB_C}
N 180 9150 180 9160 {
lab=WL_C}
N 70 9150 180 9150 {
lab=WL_C}
N 220 9130 220 9160 {
lab=WLB_C}
N 200 9130 220 9130 {
lab=WLB_C}
N 220 9280 220 9310 {
lab=VDD}
N 180 9280 180 9310 {
lab=GND}
N -30 9350 200 9350 {
lab=WLB_C}
N 180 9370 180 9380 {
lab=WL_C}
N 70 9370 180 9370 {
lab=WL_C}
N 220 9350 220 9380 {
lab=WLB_C}
N 200 9350 220 9350 {
lab=WLB_C}
N 220 9500 220 9530 {
lab=VDD}
N 180 9500 180 9530 {
lab=GND}
N -30 9580 200 9580 {
lab=WLB_C}
N 180 9600 180 9610 {
lab=WL_C}
N 70 9600 180 9600 {
lab=WL_C}
N 220 9580 220 9610 {
lab=WLB_C}
N 200 9580 220 9580 {
lab=WLB_C}
N 220 9730 220 9760 {
lab=VDD}
N 180 9730 180 9760 {
lab=GND}
N -30 9840 200 9840 {
lab=WLB_C}
N 180 9860 180 9870 {
lab=WL_C}
N 70 9860 180 9860 {
lab=WL_C}
N 220 9840 220 9870 {
lab=WLB_C}
N 200 9840 220 9840 {
lab=WLB_C}
N 220 9990 220 10020 {
lab=VDD}
N 180 9990 180 10020 {
lab=GND}
N -30 10100 200 10100 {
lab=WLB_C}
N 180 10120 180 10130 {
lab=WL_C}
N 70 10120 180 10120 {
lab=WL_C}
N 220 10100 220 10130 {
lab=WLB_C}
N 200 10100 220 10100 {
lab=WLB_C}
N 220 10250 220 10280 {
lab=VDD}
N 180 10250 180 10280 {
lab=GND}
N -30 10320 200 10320 {
lab=WLB_C}
N 180 10340 180 10350 {
lab=WL_C}
N 70 10340 180 10340 {
lab=WL_C}
N 220 10320 220 10350 {
lab=WLB_C}
N 200 10320 220 10320 {
lab=WLB_C}
N 220 10470 220 10500 {
lab=VDD}
N 180 10470 180 10500 {
lab=GND}
N -30 10550 200 10550 {
lab=WLB_C}
N 180 10570 180 10580 {
lab=WL_C}
N 70 10570 180 10570 {
lab=WL_C}
N 220 10550 220 10580 {
lab=WLB_C}
N 200 10550 220 10550 {
lab=WLB_C}
N 180 10700 180 10730 {
lab=GND}
N 40 7050 40 10650 {
lab=BL_SEL}
N 340 7050 340 10650 {
lab=BLB_SEL}
N 40 6880 40 7050 {
lab=BL_SEL}
N 340 6880 340 7050 {
lab=BLB_SEL}
N -30 10720 200 10720 {
lab=WLB_C}
N 180 10740 180 10750 {
lab=WL_C}
N 70 10740 180 10740 {
lab=WL_C}
N 220 10720 220 10750 {
lab=WLB_C}
N 200 10720 220 10720 {
lab=WLB_C}
N 220 10870 220 10900 {
lab=VDD}
N 180 10870 180 10900 {
lab=GND}
N -30 10980 200 10980 {
lab=WLB_C}
N 180 11000 180 11010 {
lab=WL_C}
N 70 11000 180 11000 {
lab=WL_C}
N 220 10980 220 11010 {
lab=WLB_C}
N 200 10980 220 10980 {
lab=WLB_C}
N 220 11130 220 11160 {
lab=VDD}
N 180 11130 180 11160 {
lab=GND}
N -30 11200 200 11200 {
lab=WLB_C}
N 180 11220 180 11230 {
lab=WL_C}
N 70 11220 180 11220 {
lab=WL_C}
N 220 11200 220 11230 {
lab=WLB_C}
N 200 11200 220 11200 {
lab=WLB_C}
N 220 11350 220 11380 {
lab=VDD}
N 180 11350 180 11380 {
lab=GND}
N -30 11430 200 11430 {
lab=WLB_C}
N 180 11450 180 11460 {
lab=WL_C}
N 70 11450 180 11450 {
lab=WL_C}
N 220 11430 220 11460 {
lab=WLB_C}
N 200 11430 220 11430 {
lab=WLB_C}
N 220 11580 220 11610 {
lab=VDD}
N 180 11580 180 11610 {
lab=GND}
N -30 11690 200 11690 {
lab=WLB_C}
N 180 11710 180 11720 {
lab=WL_C}
N 70 11710 180 11710 {
lab=WL_C}
N 220 11690 220 11720 {
lab=WLB_C}
N 200 11690 220 11690 {
lab=WLB_C}
N 220 11840 220 11870 {
lab=VDD}
N 180 11840 180 11870 {
lab=GND}
N -30 11950 200 11950 {
lab=WLB_C}
N 180 11970 180 11980 {
lab=WL_C}
N 70 11970 180 11970 {
lab=WL_C}
N 220 11950 220 11980 {
lab=WLB_C}
N 200 11950 220 11950 {
lab=WLB_C}
N 220 12100 220 12130 {
lab=VDD}
N 180 12100 180 12130 {
lab=GND}
N -30 12170 200 12170 {
lab=WLB_C}
N 180 12190 180 12200 {
lab=WL_C}
N 70 12190 180 12190 {
lab=WL_C}
N 220 12170 220 12200 {
lab=WLB_C}
N 200 12170 220 12170 {
lab=WLB_C}
N 220 12320 220 12350 {
lab=VDD}
N 180 12320 180 12350 {
lab=GND}
N -30 12400 200 12400 {
lab=WLB_C}
N 180 12420 180 12430 {
lab=WL_C}
N 70 12420 180 12420 {
lab=WL_C}
N 220 12400 220 12430 {
lab=WLB_C}
N 200 12400 220 12400 {
lab=WLB_C}
N 220 12550 220 12580 {
lab=VDD}
N 180 12550 180 12580 {
lab=GND}
N -30 12640 200 12640 {
lab=WLB_C}
N 180 12660 180 12670 {
lab=WL_C}
N 70 12660 180 12660 {
lab=WL_C}
N 220 12640 220 12670 {
lab=WLB_C}
N 200 12640 220 12640 {
lab=WLB_C}
N 220 12790 220 12820 {
lab=VDD}
N 180 12790 180 12820 {
lab=GND}
N -30 12900 200 12900 {
lab=WLB_C}
N 180 12920 180 12930 {
lab=WL_C}
N 70 12920 180 12920 {
lab=WL_C}
N 220 12900 220 12930 {
lab=WLB_C}
N 200 12900 220 12900 {
lab=WLB_C}
N 220 13050 220 13080 {
lab=VDD}
N 180 13050 180 13080 {
lab=GND}
N -30 13120 200 13120 {
lab=WLB_C}
N 180 13140 180 13150 {
lab=WL_C}
N 70 13140 180 13140 {
lab=WL_C}
N 220 13120 220 13150 {
lab=WLB_C}
N 200 13120 220 13120 {
lab=WLB_C}
N 220 13270 220 13300 {
lab=VDD}
N 180 13270 180 13300 {
lab=GND}
N -30 13350 200 13350 {
lab=WLB_C}
N 180 13370 180 13380 {
lab=WL_C}
N 70 13370 180 13370 {
lab=WL_C}
N 220 13350 220 13380 {
lab=WLB_C}
N 200 13350 220 13350 {
lab=WLB_C}
N 220 13500 220 13530 {
lab=VDD}
N 180 13500 180 13530 {
lab=GND}
N -30 13610 200 13610 {
lab=WLB_C}
N 180 13630 180 13640 {
lab=WL_C}
N 70 13630 180 13630 {
lab=WL_C}
N 220 13610 220 13640 {
lab=WLB_C}
N 200 13610 220 13610 {
lab=WLB_C}
N 220 13760 220 13790 {
lab=VDD}
N 180 13760 180 13790 {
lab=GND}
N -30 13870 200 13870 {
lab=WLB_C}
N 180 13890 180 13900 {
lab=WL_C}
N 70 13890 180 13890 {
lab=WL_C}
N 220 13870 220 13900 {
lab=WLB_C}
N 200 13870 220 13870 {
lab=WLB_C}
N 220 14020 220 14050 {
lab=VDD}
N 180 14020 180 14050 {
lab=GND}
N -30 14090 200 14090 {
lab=WLB_C}
N 180 14110 180 14120 {
lab=WL_C}
N 70 14110 180 14110 {
lab=WL_C}
N 220 14090 220 14120 {
lab=WLB_C}
N 200 14090 220 14090 {
lab=WLB_C}
N 220 14240 220 14270 {
lab=VDD}
N 180 14240 180 14270 {
lab=GND}
N -30 14320 200 14320 {
lab=WLB_C}
N 180 14340 180 14350 {
lab=WL_C}
N 70 14340 180 14340 {
lab=WL_C}
N 220 14320 220 14350 {
lab=WLB_C}
N 200 14320 220 14320 {
lab=WLB_C}
N 180 14470 180 14500 {
lab=GND}
N 40 10820 40 14420 {
lab=BL_SEL}
N 340 10820 340 14420 {
lab=BLB_SEL}
N 40 10650 40 10820 {
lab=BL_SEL}
N 340 10650 340 10820 {
lab=BLB_SEL}
N -30 14490 200 14490 {
lab=WLB_C}
N 180 14510 180 14520 {
lab=WL_C}
N 70 14510 180 14510 {
lab=WL_C}
N 220 14490 220 14520 {
lab=WLB_C}
N 200 14490 220 14490 {
lab=WLB_C}
N 220 14640 220 14670 {
lab=VDD}
N 180 14640 180 14670 {
lab=GND}
N -30 14750 200 14750 {
lab=WLB_C}
N 180 14770 180 14780 {
lab=WL_C}
N 70 14770 180 14770 {
lab=WL_C}
N 220 14750 220 14780 {
lab=WLB_C}
N 200 14750 220 14750 {
lab=WLB_C}
N 220 14900 220 14930 {
lab=VDD}
N 180 14900 180 14930 {
lab=GND}
N -30 14970 200 14970 {
lab=WLB_C}
N 180 14990 180 15000 {
lab=WL_C}
N 70 14990 180 14990 {
lab=WL_C}
N 220 14970 220 15000 {
lab=WLB_C}
N 200 14970 220 14970 {
lab=WLB_C}
N 220 15120 220 15150 {
lab=VDD}
N 180 15120 180 15150 {
lab=GND}
N -30 15200 200 15200 {
lab=WLB_C}
N 180 15220 180 15230 {
lab=WL_C}
N 70 15220 180 15220 {
lab=WL_C}
N 220 15200 220 15230 {
lab=WLB_C}
N 200 15200 220 15200 {
lab=WLB_C}
N 220 15350 220 15380 {
lab=VDD}
N 180 15350 180 15380 {
lab=GND}
N -30 15460 200 15460 {
lab=WLB_C}
N 180 15480 180 15490 {
lab=WL_C}
N 70 15480 180 15480 {
lab=WL_C}
N 220 15460 220 15490 {
lab=WLB_C}
N 200 15460 220 15460 {
lab=WLB_C}
N 220 15610 220 15640 {
lab=VDD}
N 180 15610 180 15640 {
lab=GND}
N -30 15720 200 15720 {
lab=WLB_C}
N 180 15740 180 15750 {
lab=WL_C}
N 70 15740 180 15740 {
lab=WL_C}
N 220 15720 220 15750 {
lab=WLB_C}
N 200 15720 220 15720 {
lab=WLB_C}
N 220 15870 220 15900 {
lab=VDD}
N 180 15870 180 15900 {
lab=GND}
N -30 15940 200 15940 {
lab=WLB_C}
N 180 15960 180 15970 {
lab=WL_C}
N 70 15960 180 15960 {
lab=WL_C}
N 220 15940 220 15970 {
lab=WLB_C}
N 200 15940 220 15940 {
lab=WLB_C}
N 220 16090 220 16120 {
lab=VDD}
N 180 16090 180 16120 {
lab=GND}
N -30 16170 200 16170 {
lab=WLB_C}
N 180 16190 180 16200 {
lab=WL_C}
N 70 16190 180 16190 {
lab=WL_C}
N 220 16170 220 16200 {
lab=WLB_C}
N 200 16170 220 16170 {
lab=WLB_C}
N 220 16320 220 16350 {
lab=VDD}
N 180 16320 180 16350 {
lab=GND}
N -30 16410 200 16410 {
lab=WLB_C}
N 180 16430 180 16440 {
lab=WL_C}
N 70 16430 180 16430 {
lab=WL_C}
N 220 16410 220 16440 {
lab=WLB_C}
N 200 16410 220 16410 {
lab=WLB_C}
N 220 16560 220 16590 {
lab=VDD}
N 180 16560 180 16590 {
lab=GND}
N -30 16670 200 16670 {
lab=WLB_C}
N 180 16690 180 16700 {
lab=WL_C}
N 70 16690 180 16690 {
lab=WL_C}
N 220 16670 220 16700 {
lab=WLB_C}
N 200 16670 220 16670 {
lab=WLB_C}
N 220 16820 220 16850 {
lab=VDD}
N 180 16820 180 16850 {
lab=GND}
N -30 16890 200 16890 {
lab=WLB_C}
N 180 16910 180 16920 {
lab=WL_C}
N 70 16910 180 16910 {
lab=WL_C}
N 220 16890 220 16920 {
lab=WLB_C}
N 200 16890 220 16890 {
lab=WLB_C}
N 220 17040 220 17070 {
lab=VDD}
N 180 17040 180 17070 {
lab=GND}
N -30 17120 200 17120 {
lab=WLB_C}
N 180 17140 180 17150 {
lab=WL_C}
N 70 17140 180 17140 {
lab=WL_C}
N 220 17120 220 17150 {
lab=WLB_C}
N 200 17120 220 17120 {
lab=WLB_C}
N 220 17270 220 17300 {
lab=VDD}
N 180 17270 180 17300 {
lab=GND}
N -30 17380 200 17380 {
lab=WLB_C}
N 180 17400 180 17410 {
lab=WL_C}
N 70 17400 180 17400 {
lab=WL_C}
N 220 17380 220 17410 {
lab=WLB_C}
N 200 17380 220 17380 {
lab=WLB_C}
N 220 17530 220 17560 {
lab=VDD}
N 180 17530 180 17560 {
lab=GND}
N -30 17640 200 17640 {
lab=WLB_C}
N 180 17660 180 17670 {
lab=WL_C}
N 70 17660 180 17660 {
lab=WL_C}
N 220 17640 220 17670 {
lab=WLB_C}
N 200 17640 220 17640 {
lab=WLB_C}
N 220 17790 220 17820 {
lab=VDD}
N 180 17790 180 17820 {
lab=GND}
N -30 17860 200 17860 {
lab=WLB_C}
N 180 17880 180 17890 {
lab=WL_C}
N 70 17880 180 17880 {
lab=WL_C}
N 220 17860 220 17890 {
lab=WLB_C}
N 200 17860 220 17860 {
lab=WLB_C}
N 220 18010 220 18040 {
lab=VDD}
N 180 18010 180 18040 {
lab=GND}
N -30 18090 200 18090 {
lab=WLB_C}
N 180 18110 180 18120 {
lab=WL_C}
N 70 18110 180 18110 {
lab=WL_C}
N 220 18090 220 18120 {
lab=WLB_C}
N 200 18090 220 18090 {
lab=WLB_C}
N 180 18240 180 18270 {
lab=GND}
N 40 14590 40 18190 {
lab=BL_SEL}
N 340 14590 340 18190 {
lab=BLB_SEL}
N 40 14420 40 14590 {
lab=BL_SEL}
N 340 14420 340 14590 {
lab=BLB_SEL}
N -30 18260 200 18260 {
lab=WLB_C}
N 180 18280 180 18290 {
lab=WL_C}
N 70 18280 180 18280 {
lab=WL_C}
N 220 18260 220 18290 {
lab=WLB_C}
N 200 18260 220 18260 {
lab=WLB_C}
N 220 18410 220 18440 {
lab=VDD}
N 180 18410 180 18440 {
lab=GND}
N -30 18520 200 18520 {
lab=WLB_C}
N 180 18540 180 18550 {
lab=WL_C}
N 70 18540 180 18540 {
lab=WL_C}
N 220 18520 220 18550 {
lab=WLB_C}
N 200 18520 220 18520 {
lab=WLB_C}
N 220 18670 220 18700 {
lab=VDD}
N 180 18670 180 18700 {
lab=GND}
N -30 18740 200 18740 {
lab=WLB_C}
N 180 18760 180 18770 {
lab=WL_C}
N 70 18760 180 18760 {
lab=WL_C}
N 220 18740 220 18770 {
lab=WLB_C}
N 200 18740 220 18740 {
lab=WLB_C}
N 220 18890 220 18920 {
lab=VDD}
N 180 18890 180 18920 {
lab=GND}
N -30 18970 200 18970 {
lab=WLB_C}
N 180 18990 180 19000 {
lab=WL_C}
N 70 18990 180 18990 {
lab=WL_C}
N 220 18970 220 19000 {
lab=WLB_C}
N 200 18970 220 18970 {
lab=WLB_C}
N 220 19120 220 19150 {
lab=VDD}
N 180 19120 180 19150 {
lab=GND}
N -30 19230 200 19230 {
lab=WLB_C}
N 180 19250 180 19260 {
lab=WL_C}
N 70 19250 180 19250 {
lab=WL_C}
N 220 19230 220 19260 {
lab=WLB_C}
N 200 19230 220 19230 {
lab=WLB_C}
N 220 19380 220 19410 {
lab=VDD}
N 180 19380 180 19410 {
lab=GND}
N -30 19490 200 19490 {
lab=WLB_C}
N 180 19510 180 19520 {
lab=WL_C}
N 70 19510 180 19510 {
lab=WL_C}
N 220 19490 220 19520 {
lab=WLB_C}
N 200 19490 220 19490 {
lab=WLB_C}
N 220 19640 220 19670 {
lab=VDD}
N 180 19640 180 19670 {
lab=GND}
N -30 19710 200 19710 {
lab=WLB_C}
N 180 19730 180 19740 {
lab=WL_C}
N 70 19730 180 19730 {
lab=WL_C}
N 220 19710 220 19740 {
lab=WLB_C}
N 200 19710 220 19710 {
lab=WLB_C}
N 220 19860 220 19890 {
lab=VDD}
N 180 19860 180 19890 {
lab=GND}
N -30 19940 200 19940 {
lab=WLB_C}
N 180 19960 180 19970 {
lab=WL_C}
N 70 19960 180 19960 {
lab=WL_C}
N 220 19940 220 19970 {
lab=WLB_C}
N 200 19940 220 19940 {
lab=WLB_C}
N 220 20090 220 20120 {
lab=VDD}
N 180 20090 180 20120 {
lab=GND}
N -30 20180 200 20180 {
lab=WLB_C}
N 180 20200 180 20210 {
lab=WL_C}
N 70 20200 180 20200 {
lab=WL_C}
N 220 20180 220 20210 {
lab=WLB_C}
N 200 20180 220 20180 {
lab=WLB_C}
N 220 20330 220 20360 {
lab=VDD}
N 180 20330 180 20360 {
lab=GND}
N -30 20440 200 20440 {
lab=WLB_C}
N 180 20460 180 20470 {
lab=WL_C}
N 70 20460 180 20460 {
lab=WL_C}
N 220 20440 220 20470 {
lab=WLB_C}
N 200 20440 220 20440 {
lab=WLB_C}
N 220 20590 220 20620 {
lab=VDD}
N 180 20590 180 20620 {
lab=GND}
N -30 20660 200 20660 {
lab=WLB_C}
N 180 20680 180 20690 {
lab=WL_C}
N 70 20680 180 20680 {
lab=WL_C}
N 220 20660 220 20690 {
lab=WLB_C}
N 200 20660 220 20660 {
lab=WLB_C}
N 220 20810 220 20840 {
lab=VDD}
N 180 20810 180 20840 {
lab=GND}
N -30 20890 200 20890 {
lab=WLB_C}
N 180 20910 180 20920 {
lab=WL_C}
N 70 20910 180 20910 {
lab=WL_C}
N 220 20890 220 20920 {
lab=WLB_C}
N 200 20890 220 20890 {
lab=WLB_C}
N 220 21040 220 21070 {
lab=VDD}
N 180 21040 180 21070 {
lab=GND}
N -30 21150 200 21150 {
lab=WLB_C}
N 180 21170 180 21180 {
lab=WL_C}
N 70 21170 180 21170 {
lab=WL_C}
N 220 21150 220 21180 {
lab=WLB_C}
N 200 21150 220 21150 {
lab=WLB_C}
N 220 21300 220 21330 {
lab=VDD}
N 180 21300 180 21330 {
lab=GND}
N -30 21410 200 21410 {
lab=WLB_C}
N 180 21430 180 21440 {
lab=WL_C}
N 70 21430 180 21430 {
lab=WL_C}
N 220 21410 220 21440 {
lab=WLB_C}
N 200 21410 220 21410 {
lab=WLB_C}
N 220 21560 220 21590 {
lab=VDD}
N 180 21560 180 21590 {
lab=GND}
N -30 21630 200 21630 {
lab=WLB_C}
N 180 21650 180 21660 {
lab=WL_C}
N 70 21650 180 21650 {
lab=WL_C}
N 220 21630 220 21660 {
lab=WLB_C}
N 200 21630 220 21630 {
lab=WLB_C}
N 220 21780 220 21810 {
lab=VDD}
N 180 21780 180 21810 {
lab=GND}
N -30 21860 200 21860 {
lab=WLB_C}
N 180 21880 180 21890 {
lab=WL_C}
N 70 21880 180 21880 {
lab=WL_C}
N 220 21860 220 21890 {
lab=WLB_C}
N 200 21860 220 21860 {
lab=WLB_C}
N 180 22010 180 22040 {
lab=GND}
N 40 18360 40 21960 {
lab=BL_SEL}
N 340 18360 340 21960 {
lab=BLB_SEL}
N 40 18190 40 18360 {
lab=BL_SEL}
N 340 18190 340 18360 {
lab=BLB_SEL}
N -30 22030 200 22030 {
lab=WLB_C}
N 180 22050 180 22060 {
lab=WL_C}
N 70 22050 180 22050 {
lab=WL_C}
N 220 22030 220 22060 {
lab=WLB_C}
N 200 22030 220 22030 {
lab=WLB_C}
N 220 22180 220 22210 {
lab=VDD}
N 180 22180 180 22210 {
lab=GND}
N -30 22290 200 22290 {
lab=WLB_C}
N 180 22310 180 22320 {
lab=WL_C}
N 70 22310 180 22310 {
lab=WL_C}
N 220 22290 220 22320 {
lab=WLB_C}
N 200 22290 220 22290 {
lab=WLB_C}
N 220 22440 220 22470 {
lab=VDD}
N 180 22440 180 22470 {
lab=GND}
N -30 22510 200 22510 {
lab=WLB_C}
N 180 22530 180 22540 {
lab=WL_C}
N 70 22530 180 22530 {
lab=WL_C}
N 220 22510 220 22540 {
lab=WLB_C}
N 200 22510 220 22510 {
lab=WLB_C}
N 220 22660 220 22690 {
lab=VDD}
N 180 22660 180 22690 {
lab=GND}
N -30 22740 200 22740 {
lab=WLB_C}
N 180 22760 180 22770 {
lab=WL_C}
N 70 22760 180 22760 {
lab=WL_C}
N 220 22740 220 22770 {
lab=WLB_C}
N 200 22740 220 22740 {
lab=WLB_C}
N 220 22890 220 22920 {
lab=VDD}
N 180 22890 180 22920 {
lab=GND}
N -30 23000 200 23000 {
lab=WLB_C}
N 180 23020 180 23030 {
lab=WL_C}
N 70 23020 180 23020 {
lab=WL_C}
N 220 23000 220 23030 {
lab=WLB_C}
N 200 23000 220 23000 {
lab=WLB_C}
N 220 23150 220 23180 {
lab=VDD}
N 180 23150 180 23180 {
lab=GND}
N -30 23260 200 23260 {
lab=WLB_C}
N 180 23280 180 23290 {
lab=WL_C}
N 70 23280 180 23280 {
lab=WL_C}
N 220 23260 220 23290 {
lab=WLB_C}
N 200 23260 220 23260 {
lab=WLB_C}
N 220 23410 220 23440 {
lab=VDD}
N 180 23410 180 23440 {
lab=GND}
N -30 23480 200 23480 {
lab=WLB_C}
N 180 23500 180 23510 {
lab=WL_C}
N 70 23500 180 23500 {
lab=WL_C}
N 220 23480 220 23510 {
lab=WLB_C}
N 200 23480 220 23480 {
lab=WLB_C}
N 220 23630 220 23660 {
lab=VDD}
N 180 23630 180 23660 {
lab=GND}
N -30 23710 200 23710 {
lab=WLB_C}
N 180 23730 180 23740 {
lab=WL_C}
N 70 23730 180 23730 {
lab=WL_C}
N 220 23710 220 23740 {
lab=WLB_C}
N 200 23710 220 23710 {
lab=WLB_C}
N 220 23860 220 23890 {
lab=VDD}
N 180 23860 180 23890 {
lab=GND}
N -30 23950 200 23950 {
lab=WLB_C}
N 180 23970 180 23980 {
lab=WL_C}
N 70 23970 180 23970 {
lab=WL_C}
N 220 23950 220 23980 {
lab=WLB_C}
N 200 23950 220 23950 {
lab=WLB_C}
N 220 24100 220 24130 {
lab=VDD}
N 180 24100 180 24130 {
lab=GND}
N -30 24210 200 24210 {
lab=WLB_C}
N 180 24230 180 24240 {
lab=WL_C}
N 70 24230 180 24230 {
lab=WL_C}
N 220 24210 220 24240 {
lab=WLB_C}
N 200 24210 220 24210 {
lab=WLB_C}
N 220 24360 220 24390 {
lab=VDD}
N 180 24360 180 24390 {
lab=GND}
N -30 24430 200 24430 {
lab=WLB_C}
N 180 24450 180 24460 {
lab=WL_C}
N 70 24450 180 24450 {
lab=WL_C}
N 220 24430 220 24460 {
lab=WLB_C}
N 200 24430 220 24430 {
lab=WLB_C}
N 220 24580 220 24610 {
lab=VDD}
N 180 24580 180 24610 {
lab=GND}
N -30 24660 200 24660 {
lab=WLB_C}
N 180 24680 180 24690 {
lab=WL_C}
N 70 24680 180 24680 {
lab=WL_C}
N 220 24660 220 24690 {
lab=WLB_C}
N 200 24660 220 24660 {
lab=WLB_C}
N 220 24810 220 24840 {
lab=VDD}
N 180 24810 180 24840 {
lab=GND}
N -30 24920 200 24920 {
lab=WLB_C}
N 180 24940 180 24950 {
lab=WL_C}
N 70 24940 180 24940 {
lab=WL_C}
N 220 24920 220 24950 {
lab=WLB_C}
N 200 24920 220 24920 {
lab=WLB_C}
N 220 25070 220 25100 {
lab=VDD}
N 180 25070 180 25100 {
lab=GND}
N -30 25180 200 25180 {
lab=WLB_C}
N 180 25200 180 25210 {
lab=WL_C}
N 70 25200 180 25200 {
lab=WL_C}
N 220 25180 220 25210 {
lab=WLB_C}
N 200 25180 220 25180 {
lab=WLB_C}
N 220 25330 220 25360 {
lab=VDD}
N 180 25330 180 25360 {
lab=GND}
N -30 25400 200 25400 {
lab=WLB_C}
N 180 25420 180 25430 {
lab=WL_C}
N 70 25420 180 25420 {
lab=WL_C}
N 220 25400 220 25430 {
lab=WLB_C}
N 200 25400 220 25400 {
lab=WLB_C}
N 220 25550 220 25580 {
lab=VDD}
N 180 25550 180 25580 {
lab=GND}
N -30 25630 200 25630 {
lab=WLB_C}
N 180 25650 180 25660 {
lab=WL_C}
N 70 25650 180 25650 {
lab=WL_C}
N 220 25630 220 25660 {
lab=WLB_C}
N 200 25630 220 25630 {
lab=WLB_C}
N 180 25780 180 25810 {
lab=GND}
N 40 22130 40 25730 {
lab=BL_SEL}
N 340 22130 340 25730 {
lab=BLB_SEL}
N 40 21960 40 22130 {
lab=BL_SEL}
N 340 21960 340 22130 {
lab=BLB_SEL}
N -30 25800 200 25800 {
lab=WLB_C}
N 180 25820 180 25830 {
lab=WL_C}
N 70 25820 180 25820 {
lab=WL_C}
N 220 25800 220 25830 {
lab=WLB_C}
N 200 25800 220 25800 {
lab=WLB_C}
N 220 25950 220 25980 {
lab=VDD}
N 180 25950 180 25980 {
lab=GND}
N -30 26060 200 26060 {
lab=WLB_C}
N 180 26080 180 26090 {
lab=WL_C}
N 70 26080 180 26080 {
lab=WL_C}
N 220 26060 220 26090 {
lab=WLB_C}
N 200 26060 220 26060 {
lab=WLB_C}
N 220 26210 220 26240 {
lab=VDD}
N 180 26210 180 26240 {
lab=GND}
N -30 26280 200 26280 {
lab=WLB_C}
N 180 26300 180 26310 {
lab=WL_C}
N 70 26300 180 26300 {
lab=WL_C}
N 220 26280 220 26310 {
lab=WLB_C}
N 200 26280 220 26280 {
lab=WLB_C}
N 220 26430 220 26460 {
lab=VDD}
N 180 26430 180 26460 {
lab=GND}
N -30 26510 200 26510 {
lab=WLB_C}
N 180 26530 180 26540 {
lab=WL_C}
N 70 26530 180 26530 {
lab=WL_C}
N 220 26510 220 26540 {
lab=WLB_C}
N 200 26510 220 26510 {
lab=WLB_C}
N 220 26660 220 26690 {
lab=VDD}
N 180 26660 180 26690 {
lab=GND}
N -30 26770 200 26770 {
lab=WLB_C}
N 180 26790 180 26800 {
lab=WL_C}
N 70 26790 180 26790 {
lab=WL_C}
N 220 26770 220 26800 {
lab=WLB_C}
N 200 26770 220 26770 {
lab=WLB_C}
N 220 26920 220 26950 {
lab=VDD}
N 180 26920 180 26950 {
lab=GND}
N -30 27030 200 27030 {
lab=WLB_C}
N 180 27050 180 27060 {
lab=WL_C}
N 70 27050 180 27050 {
lab=WL_C}
N 220 27030 220 27060 {
lab=WLB_C}
N 200 27030 220 27030 {
lab=WLB_C}
N 220 27180 220 27210 {
lab=VDD}
N 180 27180 180 27210 {
lab=GND}
N -30 27250 200 27250 {
lab=WLB_C}
N 180 27270 180 27280 {
lab=WL_C}
N 70 27270 180 27270 {
lab=WL_C}
N 220 27250 220 27280 {
lab=WLB_C}
N 200 27250 220 27250 {
lab=WLB_C}
N 220 27400 220 27430 {
lab=VDD}
N 180 27400 180 27430 {
lab=GND}
N -30 27480 200 27480 {
lab=WLB_C}
N 180 27500 180 27510 {
lab=WL_C}
N 70 27500 180 27500 {
lab=WL_C}
N 220 27480 220 27510 {
lab=WLB_C}
N 200 27480 220 27480 {
lab=WLB_C}
N 220 27630 220 27660 {
lab=VDD}
N 180 27630 180 27660 {
lab=GND}
N -30 27720 200 27720 {
lab=WLB_C}
N 180 27740 180 27750 {
lab=WL_C}
N 70 27740 180 27740 {
lab=WL_C}
N 220 27720 220 27750 {
lab=WLB_C}
N 200 27720 220 27720 {
lab=WLB_C}
N 220 27870 220 27900 {
lab=VDD}
N 180 27870 180 27900 {
lab=GND}
N -30 27980 200 27980 {
lab=WLB_C}
N 180 28000 180 28010 {
lab=WL_C}
N 70 28000 180 28000 {
lab=WL_C}
N 220 27980 220 28010 {
lab=WLB_C}
N 200 27980 220 27980 {
lab=WLB_C}
N 220 28130 220 28160 {
lab=VDD}
N 180 28130 180 28160 {
lab=GND}
N -30 28200 200 28200 {
lab=WLB_C}
N 180 28220 180 28230 {
lab=WL_C}
N 70 28220 180 28220 {
lab=WL_C}
N 220 28200 220 28230 {
lab=WLB_C}
N 200 28200 220 28200 {
lab=WLB_C}
N 220 28350 220 28380 {
lab=VDD}
N 180 28350 180 28380 {
lab=GND}
N -30 28430 200 28430 {
lab=WLB_C}
N 180 28450 180 28460 {
lab=WL_C}
N 70 28450 180 28450 {
lab=WL_C}
N 220 28430 220 28460 {
lab=WLB_C}
N 200 28430 220 28430 {
lab=WLB_C}
N 220 28580 220 28610 {
lab=VDD}
N 180 28580 180 28610 {
lab=GND}
N -30 28690 200 28690 {
lab=WLB_C}
N 180 28710 180 28720 {
lab=WL_C}
N 70 28710 180 28710 {
lab=WL_C}
N 220 28690 220 28720 {
lab=WLB_C}
N 200 28690 220 28690 {
lab=WLB_C}
N 220 28840 220 28870 {
lab=VDD}
N 180 28840 180 28870 {
lab=GND}
N -30 28950 200 28950 {
lab=WLB_C}
N 180 28970 180 28980 {
lab=WL_C}
N 70 28970 180 28970 {
lab=WL_C}
N 220 28950 220 28980 {
lab=WLB_C}
N 200 28950 220 28950 {
lab=WLB_C}
N 220 29100 220 29130 {
lab=VDD}
N 180 29100 180 29130 {
lab=GND}
N -30 29170 200 29170 {
lab=WLB_C}
N 180 29190 180 29200 {
lab=WL_C}
N 70 29190 180 29190 {
lab=WL_C}
N 220 29170 220 29200 {
lab=WLB_C}
N 200 29170 220 29170 {
lab=WLB_C}
N 220 29320 220 29350 {
lab=VDD}
N 180 29320 180 29350 {
lab=GND}
N -30 29400 200 29400 {
lab=WLB_C}
N 180 29420 180 29430 {
lab=WL_C}
N 70 29420 180 29420 {
lab=WL_C}
N 220 29400 220 29430 {
lab=WLB_C}
N 200 29400 220 29400 {
lab=WLB_C}
N 180 29550 180 29580 {
lab=GND}
N 40 25900 40 29500 {
lab=BL_SEL}
N 340 25900 340 29500 {
lab=BLB_SEL}
N 40 25730 40 25900 {
lab=BL_SEL}
N 340 25730 340 25900 {
lab=BLB_SEL}
N -30 29570 200 29570 {
lab=WLB_C}
N 180 29590 180 29600 {
lab=WL_C}
N 70 29590 180 29590 {
lab=WL_C}
N 220 29570 220 29600 {
lab=WLB_C}
N 200 29570 220 29570 {
lab=WLB_C}
N 220 29720 220 29750 {
lab=VDD}
N 180 29720 180 29750 {
lab=GND}
N -30 29830 200 29830 {
lab=WLB_C}
N 180 29850 180 29860 {
lab=WL_C}
N 70 29850 180 29850 {
lab=WL_C}
N 220 29830 220 29860 {
lab=WLB_C}
N 200 29830 220 29830 {
lab=WLB_C}
N 220 29980 220 30010 {
lab=VDD}
N 180 29980 180 30010 {
lab=GND}
N -30 30050 200 30050 {
lab=WLB_C}
N 180 30070 180 30080 {
lab=WL_C}
N 70 30070 180 30070 {
lab=WL_C}
N 220 30050 220 30080 {
lab=WLB_C}
N 200 30050 220 30050 {
lab=WLB_C}
N 220 30200 220 30230 {
lab=VDD}
N 180 30200 180 30230 {
lab=GND}
N -30 30280 200 30280 {
lab=WLB_C}
N 180 30300 180 30310 {
lab=WL_C}
N 70 30300 180 30300 {
lab=WL_C}
N 220 30280 220 30310 {
lab=WLB_C}
N 200 30280 220 30280 {
lab=WLB_C}
N 220 30430 220 30460 {
lab=VDD}
N 180 30430 180 30460 {
lab=GND}
N -30 30540 200 30540 {
lab=WLB_C}
N 180 30560 180 30570 {
lab=WL_C}
N 70 30560 180 30560 {
lab=WL_C}
N 220 30540 220 30570 {
lab=WLB_C}
N 200 30540 220 30540 {
lab=WLB_C}
N 220 30690 220 30720 {
lab=VDD}
N 180 30690 180 30720 {
lab=GND}
N -30 30800 200 30800 {
lab=WLB_C}
N 180 30820 180 30830 {
lab=WL_C}
N 70 30820 180 30820 {
lab=WL_C}
N 220 30800 220 30830 {
lab=WLB_C}
N 200 30800 220 30800 {
lab=WLB_C}
N 220 30950 220 30980 {
lab=VDD}
N 180 30950 180 30980 {
lab=GND}
N -30 31020 200 31020 {
lab=WLB_C}
N 180 31040 180 31050 {
lab=WL_C}
N 70 31040 180 31040 {
lab=WL_C}
N 220 31020 220 31050 {
lab=WLB_C}
N 200 31020 220 31020 {
lab=WLB_C}
N 220 31170 220 31200 {
lab=VDD}
N 180 31170 180 31200 {
lab=GND}
N -30 31250 200 31250 {
lab=WLB_C}
N 180 31270 180 31280 {
lab=WL_C}
N 70 31270 180 31270 {
lab=WL_C}
N 220 31250 220 31280 {
lab=WLB_C}
N 200 31250 220 31250 {
lab=WLB_C}
N 220 31400 220 31430 {
lab=VDD}
N 180 31400 180 31430 {
lab=GND}
N -30 31490 200 31490 {
lab=WLB_C}
N 180 31510 180 31520 {
lab=WL_C}
N 70 31510 180 31510 {
lab=WL_C}
N 220 31490 220 31520 {
lab=WLB_C}
N 200 31490 220 31490 {
lab=WLB_C}
N 220 31640 220 31670 {
lab=VDD}
N 180 31640 180 31670 {
lab=GND}
N -30 31750 200 31750 {
lab=WLB_C}
N 180 31770 180 31780 {
lab=WL_C}
N 70 31770 180 31770 {
lab=WL_C}
N 220 31750 220 31780 {
lab=WLB_C}
N 200 31750 220 31750 {
lab=WLB_C}
N 220 31900 220 31930 {
lab=VDD}
N 180 31900 180 31930 {
lab=GND}
N -30 31970 200 31970 {
lab=WLB_C}
N 180 31990 180 32000 {
lab=WL_C}
N 70 31990 180 31990 {
lab=WL_C}
N 220 31970 220 32000 {
lab=WLB_C}
N 200 31970 220 31970 {
lab=WLB_C}
N 220 32120 220 32150 {
lab=VDD}
N 180 32120 180 32150 {
lab=GND}
N -30 32200 200 32200 {
lab=WLB_C}
N 180 32220 180 32230 {
lab=WL_C}
N 70 32220 180 32220 {
lab=WL_C}
N 220 32200 220 32230 {
lab=WLB_C}
N 200 32200 220 32200 {
lab=WLB_C}
N 220 32350 220 32380 {
lab=VDD}
N 180 32350 180 32380 {
lab=GND}
N -30 32460 200 32460 {
lab=WLB_C}
N 180 32480 180 32490 {
lab=WL_C}
N 70 32480 180 32480 {
lab=WL_C}
N 220 32460 220 32490 {
lab=WLB_C}
N 200 32460 220 32460 {
lab=WLB_C}
N 220 32610 220 32640 {
lab=VDD}
N 180 32610 180 32640 {
lab=GND}
N -30 32720 200 32720 {
lab=WLB_C}
N 180 32740 180 32750 {
lab=WL_C}
N 70 32740 180 32740 {
lab=WL_C}
N 220 32720 220 32750 {
lab=WLB_C}
N 200 32720 220 32720 {
lab=WLB_C}
N 220 32870 220 32900 {
lab=VDD}
N 180 32870 180 32900 {
lab=GND}
N -30 32940 200 32940 {
lab=WLB_C}
N 180 32960 180 32970 {
lab=WL_C}
N 70 32960 180 32960 {
lab=WL_C}
N 220 32940 220 32970 {
lab=WLB_C}
N 200 32940 220 32940 {
lab=WLB_C}
N 220 33090 220 33120 {
lab=VDD}
N 180 33090 180 33120 {
lab=GND}
N -30 33170 200 33170 {
lab=WLB_C}
N 180 33190 180 33200 {
lab=WL_C}
N 70 33190 180 33190 {
lab=WL_C}
N 220 33170 220 33200 {
lab=WLB_C}
N 200 33170 220 33170 {
lab=WLB_C}
N 180 33320 180 33350 {
lab=GND}
N 40 29670 40 33270 {
lab=BL_SEL}
N 340 29670 340 33270 {
lab=BLB_SEL}
N 40 29500 40 29670 {
lab=BL_SEL}
N 340 29500 340 29670 {
lab=BLB_SEL}
N -30 33340 200 33340 {
lab=WLB_C}
N 180 33360 180 33370 {
lab=WL_C}
N 70 33360 180 33360 {
lab=WL_C}
N 220 33340 220 33370 {
lab=WLB_C}
N 200 33340 220 33340 {
lab=WLB_C}
N 220 33490 220 33520 {
lab=VDD}
N 180 33490 180 33520 {
lab=GND}
N -30 33600 200 33600 {
lab=WLB_C}
N 180 33620 180 33630 {
lab=WL_C}
N 70 33620 180 33620 {
lab=WL_C}
N 220 33600 220 33630 {
lab=WLB_C}
N 200 33600 220 33600 {
lab=WLB_C}
N 220 33750 220 33780 {
lab=VDD}
N 180 33750 180 33780 {
lab=GND}
N -30 33820 200 33820 {
lab=WLB_C}
N 180 33840 180 33850 {
lab=WL_C}
N 70 33840 180 33840 {
lab=WL_C}
N 220 33820 220 33850 {
lab=WLB_C}
N 200 33820 220 33820 {
lab=WLB_C}
N 220 33970 220 34000 {
lab=VDD}
N 180 33970 180 34000 {
lab=GND}
N -30 34050 200 34050 {
lab=WLB_C}
N 180 34070 180 34080 {
lab=WL_C}
N 70 34070 180 34070 {
lab=WL_C}
N 220 34050 220 34080 {
lab=WLB_C}
N 200 34050 220 34050 {
lab=WLB_C}
N 220 34200 220 34230 {
lab=VDD}
N 180 34200 180 34230 {
lab=GND}
N -30 34310 200 34310 {
lab=WLB_C}
N 180 34330 180 34340 {
lab=WL_C}
N 70 34330 180 34330 {
lab=WL_C}
N 220 34310 220 34340 {
lab=WLB_C}
N 200 34310 220 34310 {
lab=WLB_C}
N 220 34460 220 34490 {
lab=VDD}
N 180 34460 180 34490 {
lab=GND}
N -30 34570 200 34570 {
lab=WLB_C}
N 180 34590 180 34600 {
lab=WL_C}
N 70 34590 180 34590 {
lab=WL_C}
N 220 34570 220 34600 {
lab=WLB_C}
N 200 34570 220 34570 {
lab=WLB_C}
N 220 34720 220 34750 {
lab=VDD}
N 180 34720 180 34750 {
lab=GND}
N -30 34790 200 34790 {
lab=WLB_C}
N 180 34810 180 34820 {
lab=WL_C}
N 70 34810 180 34810 {
lab=WL_C}
N 220 34790 220 34820 {
lab=WLB_C}
N 200 34790 220 34790 {
lab=WLB_C}
N 220 34940 220 34970 {
lab=VDD}
N 180 34940 180 34970 {
lab=GND}
N -30 35020 200 35020 {
lab=WLB_C}
N 180 35040 180 35050 {
lab=WL_C}
N 70 35040 180 35040 {
lab=WL_C}
N 220 35020 220 35050 {
lab=WLB_C}
N 200 35020 220 35020 {
lab=WLB_C}
N 220 35170 220 35200 {
lab=VDD}
N 180 35170 180 35200 {
lab=GND}
N -30 35260 200 35260 {
lab=WLB_C}
N 180 35280 180 35290 {
lab=WL_C}
N 70 35280 180 35280 {
lab=WL_C}
N 220 35260 220 35290 {
lab=WLB_C}
N 200 35260 220 35260 {
lab=WLB_C}
N 220 35410 220 35440 {
lab=VDD}
N 180 35410 180 35440 {
lab=GND}
N -30 35520 200 35520 {
lab=WLB_C}
N 180 35540 180 35550 {
lab=WL_C}
N 70 35540 180 35540 {
lab=WL_C}
N 220 35520 220 35550 {
lab=WLB_C}
N 200 35520 220 35520 {
lab=WLB_C}
N 220 35670 220 35700 {
lab=VDD}
N 180 35670 180 35700 {
lab=GND}
N -30 35740 200 35740 {
lab=WLB_C}
N 180 35760 180 35770 {
lab=WL_C}
N 70 35760 180 35760 {
lab=WL_C}
N 220 35740 220 35770 {
lab=WLB_C}
N 200 35740 220 35740 {
lab=WLB_C}
N 220 35890 220 35920 {
lab=VDD}
N 180 35890 180 35920 {
lab=GND}
N -30 35970 200 35970 {
lab=WLB_C}
N 180 35990 180 36000 {
lab=WL_C}
N 70 35990 180 35990 {
lab=WL_C}
N 220 35970 220 36000 {
lab=WLB_C}
N 200 35970 220 35970 {
lab=WLB_C}
N 220 36120 220 36150 {
lab=VDD}
N 180 36120 180 36150 {
lab=GND}
N -30 36230 200 36230 {
lab=WLB_C}
N 180 36250 180 36260 {
lab=WL_C}
N 70 36250 180 36250 {
lab=WL_C}
N 220 36230 220 36260 {
lab=WLB_C}
N 200 36230 220 36230 {
lab=WLB_C}
N 220 36380 220 36410 {
lab=VDD}
N 180 36380 180 36410 {
lab=GND}
N -30 36490 200 36490 {
lab=WLB_C}
N 180 36510 180 36520 {
lab=WL_C}
N 70 36510 180 36510 {
lab=WL_C}
N 220 36490 220 36520 {
lab=WLB_C}
N 200 36490 220 36490 {
lab=WLB_C}
N 220 36640 220 36670 {
lab=VDD}
N 180 36640 180 36670 {
lab=GND}
N -30 36710 200 36710 {
lab=WLB_C}
N 180 36730 180 36740 {
lab=WL_C}
N 70 36730 180 36730 {
lab=WL_C}
N 220 36710 220 36740 {
lab=WLB_C}
N 200 36710 220 36710 {
lab=WLB_C}
N 220 36860 220 36890 {
lab=VDD}
N 180 36860 180 36890 {
lab=GND}
N -30 36940 200 36940 {
lab=WLB_C}
N 180 36960 180 36970 {
lab=WL_C}
N 70 36960 180 36960 {
lab=WL_C}
N 220 36940 220 36970 {
lab=WLB_C}
N 200 36940 220 36940 {
lab=WLB_C}
N 180 37090 180 37120 {
lab=GND}
N 40 33440 40 37040 {
lab=BL_SEL}
N 340 33440 340 37040 {
lab=BLB_SEL}
N 40 33270 40 33440 {
lab=BL_SEL}
N 340 33270 340 33440 {
lab=BLB_SEL}
N -30 37110 200 37110 {
lab=WLB_C}
N 180 37130 180 37140 {
lab=WL_C}
N 70 37130 180 37130 {
lab=WL_C}
N 220 37110 220 37140 {
lab=WLB_C}
N 200 37110 220 37110 {
lab=WLB_C}
N 220 37260 220 37290 {
lab=VDD}
N 180 37260 180 37290 {
lab=GND}
N -30 37370 200 37370 {
lab=WLB_C}
N 180 37390 180 37400 {
lab=WL_C}
N 70 37390 180 37390 {
lab=WL_C}
N 220 37370 220 37400 {
lab=WLB_C}
N 200 37370 220 37370 {
lab=WLB_C}
N 220 37520 220 37550 {
lab=VDD}
N 180 37520 180 37550 {
lab=GND}
N -30 37590 200 37590 {
lab=WLB_C}
N 180 37610 180 37620 {
lab=WL_C}
N 70 37610 180 37610 {
lab=WL_C}
N 220 37590 220 37620 {
lab=WLB_C}
N 200 37590 220 37590 {
lab=WLB_C}
N 220 37740 220 37770 {
lab=VDD}
N 180 37740 180 37770 {
lab=GND}
N -30 37820 200 37820 {
lab=WLB_C}
N 180 37840 180 37850 {
lab=WL_C}
N 70 37840 180 37840 {
lab=WL_C}
N 220 37820 220 37850 {
lab=WLB_C}
N 200 37820 220 37820 {
lab=WLB_C}
N 220 37970 220 38000 {
lab=VDD}
N 180 37970 180 38000 {
lab=GND}
N -30 38080 200 38080 {
lab=WLB_C}
N 180 38100 180 38110 {
lab=WL_C}
N 70 38100 180 38100 {
lab=WL_C}
N 220 38080 220 38110 {
lab=WLB_C}
N 200 38080 220 38080 {
lab=WLB_C}
N 220 38230 220 38260 {
lab=VDD}
N 180 38230 180 38260 {
lab=GND}
N -30 38340 200 38340 {
lab=WLB_C}
N 180 38360 180 38370 {
lab=WL_C}
N 70 38360 180 38360 {
lab=WL_C}
N 220 38340 220 38370 {
lab=WLB_C}
N 200 38340 220 38340 {
lab=WLB_C}
N 220 38490 220 38520 {
lab=VDD}
N 180 38490 180 38520 {
lab=GND}
N -30 38560 200 38560 {
lab=WLB_C}
N 180 38580 180 38590 {
lab=WL_C}
N 70 38580 180 38580 {
lab=WL_C}
N 220 38560 220 38590 {
lab=WLB_C}
N 200 38560 220 38560 {
lab=WLB_C}
N 220 38710 220 38740 {
lab=VDD}
N 180 38710 180 38740 {
lab=GND}
N -30 38790 200 38790 {
lab=WLB_C}
N 180 38810 180 38820 {
lab=WL_C}
N 70 38810 180 38810 {
lab=WL_C}
N 220 38790 220 38820 {
lab=WLB_C}
N 200 38790 220 38790 {
lab=WLB_C}
N 220 38940 220 38970 {
lab=VDD}
N 180 38940 180 38970 {
lab=GND}
N -30 39030 200 39030 {
lab=WLB_C}
N 180 39050 180 39060 {
lab=WL_C}
N 70 39050 180 39050 {
lab=WL_C}
N 220 39030 220 39060 {
lab=WLB_C}
N 200 39030 220 39030 {
lab=WLB_C}
N 220 39180 220 39210 {
lab=VDD}
N 180 39180 180 39210 {
lab=GND}
N -30 39290 200 39290 {
lab=WLB_C}
N 180 39310 180 39320 {
lab=WL_C}
N 70 39310 180 39310 {
lab=WL_C}
N 220 39290 220 39320 {
lab=WLB_C}
N 200 39290 220 39290 {
lab=WLB_C}
N 220 39440 220 39470 {
lab=VDD}
N 180 39440 180 39470 {
lab=GND}
N -30 39510 200 39510 {
lab=WLB_C}
N 180 39530 180 39540 {
lab=WL_C}
N 70 39530 180 39530 {
lab=WL_C}
N 220 39510 220 39540 {
lab=WLB_C}
N 200 39510 220 39510 {
lab=WLB_C}
N 220 39660 220 39690 {
lab=VDD}
N 180 39660 180 39690 {
lab=GND}
N -30 39740 200 39740 {
lab=WLB_C}
N 180 39760 180 39770 {
lab=WL_C}
N 70 39760 180 39760 {
lab=WL_C}
N 220 39740 220 39770 {
lab=WLB_C}
N 200 39740 220 39740 {
lab=WLB_C}
N 220 39890 220 39920 {
lab=VDD}
N 180 39890 180 39920 {
lab=GND}
N -30 40000 200 40000 {
lab=WLB_C}
N 180 40020 180 40030 {
lab=WL_C}
N 70 40020 180 40020 {
lab=WL_C}
N 220 40000 220 40030 {
lab=WLB_C}
N 200 40000 220 40000 {
lab=WLB_C}
N 220 40150 220 40180 {
lab=VDD}
N 180 40150 180 40180 {
lab=GND}
N -30 40260 200 40260 {
lab=WLB_C}
N 180 40280 180 40290 {
lab=WL_C}
N 70 40280 180 40280 {
lab=WL_C}
N 220 40260 220 40290 {
lab=WLB_C}
N 200 40260 220 40260 {
lab=WLB_C}
N 220 40410 220 40440 {
lab=VDD}
N 180 40410 180 40440 {
lab=GND}
N -30 40480 200 40480 {
lab=WLB_C}
N 180 40500 180 40510 {
lab=WL_C}
N 70 40500 180 40500 {
lab=WL_C}
N 220 40480 220 40510 {
lab=WLB_C}
N 200 40480 220 40480 {
lab=WLB_C}
N 220 40630 220 40660 {
lab=VDD}
N 180 40630 180 40660 {
lab=GND}
N -30 40710 200 40710 {
lab=WLB_C}
N 180 40730 180 40740 {
lab=WL_C}
N 70 40730 180 40730 {
lab=WL_C}
N 220 40710 220 40740 {
lab=WLB_C}
N 200 40710 220 40710 {
lab=WLB_C}
N 180 40860 180 40890 {
lab=GND}
N 40 37210 40 40810 {
lab=BL_SEL}
N 340 37210 340 40810 {
lab=BLB_SEL}
N 40 37040 40 37210 {
lab=BL_SEL}
N 340 37040 340 37210 {
lab=BLB_SEL}
N -30 40880 200 40880 {
lab=WLB_C}
N 180 40900 180 40910 {
lab=WL_C}
N 70 40900 180 40900 {
lab=WL_C}
N 220 40880 220 40910 {
lab=WLB_C}
N 200 40880 220 40880 {
lab=WLB_C}
N 220 41030 220 41060 {
lab=VDD}
N 180 41030 180 41060 {
lab=GND}
N -30 41140 200 41140 {
lab=WLB_C}
N 180 41160 180 41170 {
lab=WL_C}
N 70 41160 180 41160 {
lab=WL_C}
N 220 41140 220 41170 {
lab=WLB_C}
N 200 41140 220 41140 {
lab=WLB_C}
N 220 41290 220 41320 {
lab=VDD}
N 180 41290 180 41320 {
lab=GND}
N -30 41360 200 41360 {
lab=WLB_C}
N 180 41380 180 41390 {
lab=WL_C}
N 70 41380 180 41380 {
lab=WL_C}
N 220 41360 220 41390 {
lab=WLB_C}
N 200 41360 220 41360 {
lab=WLB_C}
N 220 41510 220 41540 {
lab=VDD}
N 180 41510 180 41540 {
lab=GND}
N -30 41590 200 41590 {
lab=WLB_C}
N 180 41610 180 41620 {
lab=WL_C}
N 70 41610 180 41610 {
lab=WL_C}
N 220 41590 220 41620 {
lab=WLB_C}
N 200 41590 220 41590 {
lab=WLB_C}
N 220 41740 220 41770 {
lab=VDD}
N 180 41740 180 41770 {
lab=GND}
N -30 41850 200 41850 {
lab=WLB_C}
N 180 41870 180 41880 {
lab=WL_C}
N 70 41870 180 41870 {
lab=WL_C}
N 220 41850 220 41880 {
lab=WLB_C}
N 200 41850 220 41850 {
lab=WLB_C}
N 220 42000 220 42030 {
lab=VDD}
N 180 42000 180 42030 {
lab=GND}
N -30 42110 200 42110 {
lab=WLB_C}
N 180 42130 180 42140 {
lab=WL_C}
N 70 42130 180 42130 {
lab=WL_C}
N 220 42110 220 42140 {
lab=WLB_C}
N 200 42110 220 42110 {
lab=WLB_C}
N 220 42260 220 42290 {
lab=VDD}
N 180 42260 180 42290 {
lab=GND}
N -30 42330 200 42330 {
lab=WLB_C}
N 180 42350 180 42360 {
lab=WL_C}
N 70 42350 180 42350 {
lab=WL_C}
N 220 42330 220 42360 {
lab=WLB_C}
N 200 42330 220 42330 {
lab=WLB_C}
N 220 42480 220 42510 {
lab=VDD}
N 180 42480 180 42510 {
lab=GND}
N -30 42560 200 42560 {
lab=WLB_C}
N 180 42580 180 42590 {
lab=WL_C}
N 70 42580 180 42580 {
lab=WL_C}
N 220 42560 220 42590 {
lab=WLB_C}
N 200 42560 220 42560 {
lab=WLB_C}
N 220 42710 220 42740 {
lab=VDD}
N 180 42710 180 42740 {
lab=GND}
N -30 42800 200 42800 {
lab=WLB_C}
N 180 42820 180 42830 {
lab=WL_C}
N 70 42820 180 42820 {
lab=WL_C}
N 220 42800 220 42830 {
lab=WLB_C}
N 200 42800 220 42800 {
lab=WLB_C}
N 220 42950 220 42980 {
lab=VDD}
N 180 42950 180 42980 {
lab=GND}
N -30 43060 200 43060 {
lab=WLB_C}
N 180 43080 180 43090 {
lab=WL_C}
N 70 43080 180 43080 {
lab=WL_C}
N 220 43060 220 43090 {
lab=WLB_C}
N 200 43060 220 43060 {
lab=WLB_C}
N 220 43210 220 43240 {
lab=VDD}
N 180 43210 180 43240 {
lab=GND}
N -30 43280 200 43280 {
lab=WLB_C}
N 180 43300 180 43310 {
lab=WL_C}
N 70 43300 180 43300 {
lab=WL_C}
N 220 43280 220 43310 {
lab=WLB_C}
N 200 43280 220 43280 {
lab=WLB_C}
N 220 43430 220 43460 {
lab=VDD}
N 180 43430 180 43460 {
lab=GND}
N -30 43510 200 43510 {
lab=WLB_C}
N 180 43530 180 43540 {
lab=WL_C}
N 70 43530 180 43530 {
lab=WL_C}
N 220 43510 220 43540 {
lab=WLB_C}
N 200 43510 220 43510 {
lab=WLB_C}
N 220 43660 220 43690 {
lab=VDD}
N 180 43660 180 43690 {
lab=GND}
N -30 43770 200 43770 {
lab=WLB_C}
N 180 43790 180 43800 {
lab=WL_C}
N 70 43790 180 43790 {
lab=WL_C}
N 220 43770 220 43800 {
lab=WLB_C}
N 200 43770 220 43770 {
lab=WLB_C}
N 220 43920 220 43950 {
lab=VDD}
N 180 43920 180 43950 {
lab=GND}
N -30 44030 200 44030 {
lab=WLB_C}
N 180 44050 180 44060 {
lab=WL_C}
N 70 44050 180 44050 {
lab=WL_C}
N 220 44030 220 44060 {
lab=WLB_C}
N 200 44030 220 44030 {
lab=WLB_C}
N 220 44180 220 44210 {
lab=VDD}
N 180 44180 180 44210 {
lab=GND}
N -30 44250 200 44250 {
lab=WLB_C}
N 180 44270 180 44280 {
lab=WL_C}
N 70 44270 180 44270 {
lab=WL_C}
N 220 44250 220 44280 {
lab=WLB_C}
N 200 44250 220 44250 {
lab=WLB_C}
N 220 44400 220 44430 {
lab=VDD}
N 180 44400 180 44430 {
lab=GND}
N -30 44480 200 44480 {
lab=WLB_C}
N 180 44500 180 44510 {
lab=WL_C}
N 70 44500 180 44500 {
lab=WL_C}
N 220 44480 220 44510 {
lab=WLB_C}
N 200 44480 220 44480 {
lab=WLB_C}
N 180 44630 180 44660 {
lab=GND}
N 40 40980 40 44580 {
lab=BL_SEL}
N 340 40980 340 44580 {
lab=BLB_SEL}
N 40 40810 40 40980 {
lab=BL_SEL}
N 340 40810 340 40980 {
lab=BLB_SEL}
N -30 44650 200 44650 {
lab=WLB_C}
N 180 44670 180 44680 {
lab=WL_C}
N 70 44670 180 44670 {
lab=WL_C}
N 220 44650 220 44680 {
lab=WLB_C}
N 200 44650 220 44650 {
lab=WLB_C}
N 220 44800 220 44830 {
lab=VDD}
N 180 44800 180 44830 {
lab=GND}
N -30 44910 200 44910 {
lab=WLB_C}
N 180 44930 180 44940 {
lab=WL_C}
N 70 44930 180 44930 {
lab=WL_C}
N 220 44910 220 44940 {
lab=WLB_C}
N 200 44910 220 44910 {
lab=WLB_C}
N 220 45060 220 45090 {
lab=VDD}
N 180 45060 180 45090 {
lab=GND}
N -30 45130 200 45130 {
lab=WLB_C}
N 180 45150 180 45160 {
lab=WL_C}
N 70 45150 180 45150 {
lab=WL_C}
N 220 45130 220 45160 {
lab=WLB_C}
N 200 45130 220 45130 {
lab=WLB_C}
N 220 45280 220 45310 {
lab=VDD}
N 180 45280 180 45310 {
lab=GND}
N -30 45360 200 45360 {
lab=WLB_C}
N 180 45380 180 45390 {
lab=WL_C}
N 70 45380 180 45380 {
lab=WL_C}
N 220 45360 220 45390 {
lab=WLB_C}
N 200 45360 220 45360 {
lab=WLB_C}
N 220 45510 220 45540 {
lab=VDD}
N 180 45510 180 45540 {
lab=GND}
N -30 45620 200 45620 {
lab=WLB_C}
N 180 45640 180 45650 {
lab=WL_C}
N 70 45640 180 45640 {
lab=WL_C}
N 220 45620 220 45650 {
lab=WLB_C}
N 200 45620 220 45620 {
lab=WLB_C}
N 220 45770 220 45800 {
lab=VDD}
N 180 45770 180 45800 {
lab=GND}
N -30 45880 200 45880 {
lab=WLB_C}
N 180 45900 180 45910 {
lab=WL_C}
N 70 45900 180 45900 {
lab=WL_C}
N 220 45880 220 45910 {
lab=WLB_C}
N 200 45880 220 45880 {
lab=WLB_C}
N 220 46030 220 46060 {
lab=VDD}
N 180 46030 180 46060 {
lab=GND}
N -30 46100 200 46100 {
lab=WLB_C}
N 180 46120 180 46130 {
lab=WL_C}
N 70 46120 180 46120 {
lab=WL_C}
N 220 46100 220 46130 {
lab=WLB_C}
N 200 46100 220 46100 {
lab=WLB_C}
N 220 46250 220 46280 {
lab=VDD}
N 180 46250 180 46280 {
lab=GND}
N -30 46330 200 46330 {
lab=WLB_C}
N 180 46350 180 46360 {
lab=WL_C}
N 70 46350 180 46350 {
lab=WL_C}
N 220 46330 220 46360 {
lab=WLB_C}
N 200 46330 220 46330 {
lab=WLB_C}
N 220 46480 220 46510 {
lab=VDD}
N 180 46480 180 46510 {
lab=GND}
N -30 46570 200 46570 {
lab=WLB_C}
N 180 46590 180 46600 {
lab=WL_C}
N 70 46590 180 46590 {
lab=WL_C}
N 220 46570 220 46600 {
lab=WLB_C}
N 200 46570 220 46570 {
lab=WLB_C}
N 220 46720 220 46750 {
lab=VDD}
N 180 46720 180 46750 {
lab=GND}
N -30 46830 200 46830 {
lab=WLB_C}
N 180 46850 180 46860 {
lab=WL_C}
N 70 46850 180 46850 {
lab=WL_C}
N 220 46830 220 46860 {
lab=WLB_C}
N 200 46830 220 46830 {
lab=WLB_C}
N 220 46980 220 47010 {
lab=VDD}
N 180 46980 180 47010 {
lab=GND}
N -30 47050 200 47050 {
lab=WLB_C}
N 180 47070 180 47080 {
lab=WL_C}
N 70 47070 180 47070 {
lab=WL_C}
N 220 47050 220 47080 {
lab=WLB_C}
N 200 47050 220 47050 {
lab=WLB_C}
N 220 47200 220 47230 {
lab=VDD}
N 180 47200 180 47230 {
lab=GND}
N -30 47280 200 47280 {
lab=WLB_C}
N 180 47300 180 47310 {
lab=WL_C}
N 70 47300 180 47300 {
lab=WL_C}
N 220 47280 220 47310 {
lab=WLB_C}
N 200 47280 220 47280 {
lab=WLB_C}
N 220 47430 220 47460 {
lab=VDD}
N 180 47430 180 47460 {
lab=GND}
N -30 47540 200 47540 {
lab=WLB_C}
N 180 47560 180 47570 {
lab=WL_C}
N 70 47560 180 47560 {
lab=WL_C}
N 220 47540 220 47570 {
lab=WLB_C}
N 200 47540 220 47540 {
lab=WLB_C}
N 220 47690 220 47720 {
lab=VDD}
N 180 47690 180 47720 {
lab=GND}
N -30 47800 200 47800 {
lab=WLB_C}
N 180 47820 180 47830 {
lab=WL_C}
N 70 47820 180 47820 {
lab=WL_C}
N 220 47800 220 47830 {
lab=WLB_C}
N 200 47800 220 47800 {
lab=WLB_C}
N 220 47950 220 47980 {
lab=VDD}
N 180 47950 180 47980 {
lab=GND}
N -30 48020 200 48020 {
lab=WLB_C}
N 180 48040 180 48050 {
lab=WL_C}
N 70 48040 180 48040 {
lab=WL_C}
N 220 48020 220 48050 {
lab=WLB_C}
N 200 48020 220 48020 {
lab=WLB_C}
N 220 48170 220 48200 {
lab=VDD}
N 180 48170 180 48200 {
lab=GND}
N -30 48250 200 48250 {
lab=WLB_C}
N 180 48270 180 48280 {
lab=WL_C}
N 70 48270 180 48270 {
lab=WL_C}
N 220 48250 220 48280 {
lab=WLB_C}
N 200 48250 220 48250 {
lab=WLB_C}
N 180 48400 180 48430 {
lab=GND}
N 40 44750 40 48350 {
lab=BL_SEL}
N 340 44750 340 48350 {
lab=BLB_SEL}
N 40 44580 40 44750 {
lab=BL_SEL}
N 340 44580 340 44750 {
lab=BLB_SEL}
N -30 48420 200 48420 {
lab=WLB_C}
N 180 48440 180 48450 {
lab=WL_C}
N 70 48440 180 48440 {
lab=WL_C}
N 220 48420 220 48450 {
lab=WLB_C}
N 200 48420 220 48420 {
lab=WLB_C}
N 220 48570 220 48600 {
lab=VDD}
N 180 48570 180 48600 {
lab=GND}
N -30 48680 200 48680 {
lab=WLB_C}
N 180 48700 180 48710 {
lab=WL_C}
N 70 48700 180 48700 {
lab=WL_C}
N 220 48680 220 48710 {
lab=WLB_C}
N 200 48680 220 48680 {
lab=WLB_C}
N 220 48830 220 48860 {
lab=VDD}
N 180 48830 180 48860 {
lab=GND}
N -30 48900 200 48900 {
lab=WLB_C}
N 180 48920 180 48930 {
lab=WL_C}
N 70 48920 180 48920 {
lab=WL_C}
N 220 48900 220 48930 {
lab=WLB_C}
N 200 48900 220 48900 {
lab=WLB_C}
N 220 49050 220 49080 {
lab=VDD}
N 180 49050 180 49080 {
lab=GND}
N -30 49130 200 49130 {
lab=WLB_C}
N 180 49150 180 49160 {
lab=WL_C}
N 70 49150 180 49150 {
lab=WL_C}
N 220 49130 220 49160 {
lab=WLB_C}
N 200 49130 220 49130 {
lab=WLB_C}
N 220 49280 220 49310 {
lab=VDD}
N 180 49280 180 49310 {
lab=GND}
N -30 49390 200 49390 {
lab=WLB_C}
N 180 49410 180 49420 {
lab=WL_C}
N 70 49410 180 49410 {
lab=WL_C}
N 220 49390 220 49420 {
lab=WLB_C}
N 200 49390 220 49390 {
lab=WLB_C}
N 220 49540 220 49570 {
lab=VDD}
N 180 49540 180 49570 {
lab=GND}
N -30 49650 200 49650 {
lab=WLB_C}
N 180 49670 180 49680 {
lab=WL_C}
N 70 49670 180 49670 {
lab=WL_C}
N 220 49650 220 49680 {
lab=WLB_C}
N 200 49650 220 49650 {
lab=WLB_C}
N 220 49800 220 49830 {
lab=VDD}
N 180 49800 180 49830 {
lab=GND}
N -30 49870 200 49870 {
lab=WLB_C}
N 180 49890 180 49900 {
lab=WL_C}
N 70 49890 180 49890 {
lab=WL_C}
N 220 49870 220 49900 {
lab=WLB_C}
N 200 49870 220 49870 {
lab=WLB_C}
N 220 50020 220 50050 {
lab=VDD}
N 180 50020 180 50050 {
lab=GND}
N -30 50100 200 50100 {
lab=WLB_C}
N 180 50120 180 50130 {
lab=WL_C}
N 70 50120 180 50120 {
lab=WL_C}
N 220 50100 220 50130 {
lab=WLB_C}
N 200 50100 220 50100 {
lab=WLB_C}
N 220 50250 220 50280 {
lab=VDD}
N 180 50250 180 50280 {
lab=GND}
N -30 50340 200 50340 {
lab=WLB_C}
N 180 50360 180 50370 {
lab=WL_C}
N 70 50360 180 50360 {
lab=WL_C}
N 220 50340 220 50370 {
lab=WLB_C}
N 200 50340 220 50340 {
lab=WLB_C}
N 220 50490 220 50520 {
lab=VDD}
N 180 50490 180 50520 {
lab=GND}
N -30 50600 200 50600 {
lab=WLB_C}
N 180 50620 180 50630 {
lab=WL_C}
N 70 50620 180 50620 {
lab=WL_C}
N 220 50600 220 50630 {
lab=WLB_C}
N 200 50600 220 50600 {
lab=WLB_C}
N 220 50750 220 50780 {
lab=VDD}
N 180 50750 180 50780 {
lab=GND}
N -30 50820 200 50820 {
lab=WLB_C}
N 180 50840 180 50850 {
lab=WL_C}
N 70 50840 180 50840 {
lab=WL_C}
N 220 50820 220 50850 {
lab=WLB_C}
N 200 50820 220 50820 {
lab=WLB_C}
N 220 50970 220 51000 {
lab=VDD}
N 180 50970 180 51000 {
lab=GND}
N -30 51050 200 51050 {
lab=WLB_C}
N 180 51070 180 51080 {
lab=WL_C}
N 70 51070 180 51070 {
lab=WL_C}
N 220 51050 220 51080 {
lab=WLB_C}
N 200 51050 220 51050 {
lab=WLB_C}
N 220 51200 220 51230 {
lab=VDD}
N 180 51200 180 51230 {
lab=GND}
N -30 51310 200 51310 {
lab=WLB_C}
N 180 51330 180 51340 {
lab=WL_C}
N 70 51330 180 51330 {
lab=WL_C}
N 220 51310 220 51340 {
lab=WLB_C}
N 200 51310 220 51310 {
lab=WLB_C}
N 220 51460 220 51490 {
lab=VDD}
N 180 51460 180 51490 {
lab=GND}
N -30 51570 200 51570 {
lab=WLB_C}
N 180 51590 180 51600 {
lab=WL_C}
N 70 51590 180 51590 {
lab=WL_C}
N 220 51570 220 51600 {
lab=WLB_C}
N 200 51570 220 51570 {
lab=WLB_C}
N 220 51720 220 51750 {
lab=VDD}
N 180 51720 180 51750 {
lab=GND}
N -30 51790 200 51790 {
lab=WLB_C}
N 180 51810 180 51820 {
lab=WL_C}
N 70 51810 180 51810 {
lab=WL_C}
N 220 51790 220 51820 {
lab=WLB_C}
N 200 51790 220 51790 {
lab=WLB_C}
N 220 51940 220 51970 {
lab=VDD}
N 180 51940 180 51970 {
lab=GND}
N -30 52020 200 52020 {
lab=WLB_C}
N 180 52040 180 52050 {
lab=WL_C}
N 70 52040 180 52040 {
lab=WL_C}
N 220 52020 220 52050 {
lab=WLB_C}
N 200 52020 220 52020 {
lab=WLB_C}
N 180 52170 180 52200 {
lab=GND}
N 40 48520 40 52120 {
lab=BL_SEL}
N 340 48520 340 52120 {
lab=BLB_SEL}
N 40 48350 40 48520 {
lab=BL_SEL}
N 340 48350 340 48520 {
lab=BLB_SEL}
N -30 52190 200 52190 {
lab=WLB_C}
N 180 52210 180 52220 {
lab=WL_C}
N 70 52210 180 52210 {
lab=WL_C}
N 220 52190 220 52220 {
lab=WLB_C}
N 200 52190 220 52190 {
lab=WLB_C}
N 220 52340 220 52370 {
lab=VDD}
N 180 52340 180 52370 {
lab=GND}
N -30 52450 200 52450 {
lab=WLB_C}
N 180 52470 180 52480 {
lab=WL_C}
N 70 52470 180 52470 {
lab=WL_C}
N 220 52450 220 52480 {
lab=WLB_C}
N 200 52450 220 52450 {
lab=WLB_C}
N 220 52600 220 52630 {
lab=VDD}
N 180 52600 180 52630 {
lab=GND}
N -30 52670 200 52670 {
lab=WLB_C}
N 180 52690 180 52700 {
lab=WL_C}
N 70 52690 180 52690 {
lab=WL_C}
N 220 52670 220 52700 {
lab=WLB_C}
N 200 52670 220 52670 {
lab=WLB_C}
N 220 52820 220 52850 {
lab=VDD}
N 180 52820 180 52850 {
lab=GND}
N -30 52900 200 52900 {
lab=WLB_C}
N 180 52920 180 52930 {
lab=WL_C}
N 70 52920 180 52920 {
lab=WL_C}
N 220 52900 220 52930 {
lab=WLB_C}
N 200 52900 220 52900 {
lab=WLB_C}
N 220 53050 220 53080 {
lab=VDD}
N 180 53050 180 53080 {
lab=GND}
N -30 53160 200 53160 {
lab=WLB_C}
N 180 53180 180 53190 {
lab=WL_C}
N 70 53180 180 53180 {
lab=WL_C}
N 220 53160 220 53190 {
lab=WLB_C}
N 200 53160 220 53160 {
lab=WLB_C}
N 220 53310 220 53340 {
lab=VDD}
N 180 53310 180 53340 {
lab=GND}
N -30 53420 200 53420 {
lab=WLB_C}
N 180 53440 180 53450 {
lab=WL_C}
N 70 53440 180 53440 {
lab=WL_C}
N 220 53420 220 53450 {
lab=WLB_C}
N 200 53420 220 53420 {
lab=WLB_C}
N 220 53570 220 53600 {
lab=VDD}
N 180 53570 180 53600 {
lab=GND}
N -30 53640 200 53640 {
lab=WLB_C}
N 180 53660 180 53670 {
lab=WL_C}
N 70 53660 180 53660 {
lab=WL_C}
N 220 53640 220 53670 {
lab=WLB_C}
N 200 53640 220 53640 {
lab=WLB_C}
N 220 53790 220 53820 {
lab=VDD}
N 180 53790 180 53820 {
lab=GND}
N -30 53870 200 53870 {
lab=WLB_C}
N 180 53890 180 53900 {
lab=WL_C}
N 70 53890 180 53890 {
lab=WL_C}
N 220 53870 220 53900 {
lab=WLB_C}
N 200 53870 220 53870 {
lab=WLB_C}
N 220 54020 220 54050 {
lab=VDD}
N 180 54020 180 54050 {
lab=GND}
N -30 54110 200 54110 {
lab=WLB_C}
N 180 54130 180 54140 {
lab=WL_C}
N 70 54130 180 54130 {
lab=WL_C}
N 220 54110 220 54140 {
lab=WLB_C}
N 200 54110 220 54110 {
lab=WLB_C}
N 220 54260 220 54290 {
lab=VDD}
N 180 54260 180 54290 {
lab=GND}
N -30 54370 200 54370 {
lab=WLB_C}
N 180 54390 180 54400 {
lab=WL_C}
N 70 54390 180 54390 {
lab=WL_C}
N 220 54370 220 54400 {
lab=WLB_C}
N 200 54370 220 54370 {
lab=WLB_C}
N 220 54520 220 54550 {
lab=VDD}
N 180 54520 180 54550 {
lab=GND}
N -30 54590 200 54590 {
lab=WLB_C}
N 180 54610 180 54620 {
lab=WL_C}
N 70 54610 180 54610 {
lab=WL_C}
N 220 54590 220 54620 {
lab=WLB_C}
N 200 54590 220 54590 {
lab=WLB_C}
N 220 54740 220 54770 {
lab=VDD}
N 180 54740 180 54770 {
lab=GND}
N -30 54820 200 54820 {
lab=WLB_C}
N 180 54840 180 54850 {
lab=WL_C}
N 70 54840 180 54840 {
lab=WL_C}
N 220 54820 220 54850 {
lab=WLB_C}
N 200 54820 220 54820 {
lab=WLB_C}
N 220 54970 220 55000 {
lab=VDD}
N 180 54970 180 55000 {
lab=GND}
N -30 55080 200 55080 {
lab=WLB_C}
N 180 55100 180 55110 {
lab=WL_C}
N 70 55100 180 55100 {
lab=WL_C}
N 220 55080 220 55110 {
lab=WLB_C}
N 200 55080 220 55080 {
lab=WLB_C}
N 220 55230 220 55260 {
lab=VDD}
N 180 55230 180 55260 {
lab=GND}
N -30 55340 200 55340 {
lab=WLB_C}
N 180 55360 180 55370 {
lab=WL_C}
N 70 55360 180 55360 {
lab=WL_C}
N 220 55340 220 55370 {
lab=WLB_C}
N 200 55340 220 55340 {
lab=WLB_C}
N 220 55490 220 55520 {
lab=VDD}
N 180 55490 180 55520 {
lab=GND}
N -30 55560 200 55560 {
lab=WLB_C}
N 180 55580 180 55590 {
lab=WL_C}
N 70 55580 180 55580 {
lab=WL_C}
N 220 55560 220 55590 {
lab=WLB_C}
N 200 55560 220 55560 {
lab=WLB_C}
N 220 55710 220 55740 {
lab=VDD}
N 180 55710 180 55740 {
lab=GND}
N -30 55790 200 55790 {
lab=WLB_C}
N 180 55810 180 55820 {
lab=WL_C}
N 70 55810 180 55810 {
lab=WL_C}
N 220 55790 220 55820 {
lab=WLB_C}
N 200 55790 220 55790 {
lab=WLB_C}
N 180 55940 180 55970 {
lab=GND}
N 40 52290 40 55890 {
lab=BL_SEL}
N 340 52290 340 55890 {
lab=BLB_SEL}
N 40 52120 40 52290 {
lab=BL_SEL}
N 340 52120 340 52290 {
lab=BLB_SEL}
N -30 55960 200 55960 {
lab=WLB_C}
N 180 55980 180 55990 {
lab=WL_C}
N 70 55980 180 55980 {
lab=WL_C}
N 220 55960 220 55990 {
lab=WLB_C}
N 200 55960 220 55960 {
lab=WLB_C}
N 220 56110 220 56140 {
lab=VDD}
N 180 56110 180 56140 {
lab=GND}
N -30 56220 200 56220 {
lab=WLB_C}
N 180 56240 180 56250 {
lab=WL_C}
N 70 56240 180 56240 {
lab=WL_C}
N 220 56220 220 56250 {
lab=WLB_C}
N 200 56220 220 56220 {
lab=WLB_C}
N 220 56370 220 56400 {
lab=VDD}
N 180 56370 180 56400 {
lab=GND}
N -30 56440 200 56440 {
lab=WLB_C}
N 180 56460 180 56470 {
lab=WL_C}
N 70 56460 180 56460 {
lab=WL_C}
N 220 56440 220 56470 {
lab=WLB_C}
N 200 56440 220 56440 {
lab=WLB_C}
N 220 56590 220 56620 {
lab=VDD}
N 180 56590 180 56620 {
lab=GND}
N -30 56670 200 56670 {
lab=WLB_C}
N 180 56690 180 56700 {
lab=WL_C}
N 70 56690 180 56690 {
lab=WL_C}
N 220 56670 220 56700 {
lab=WLB_C}
N 200 56670 220 56670 {
lab=WLB_C}
N 220 56820 220 56850 {
lab=VDD}
N 180 56820 180 56850 {
lab=GND}
N -30 56930 200 56930 {
lab=WLB_C}
N 180 56950 180 56960 {
lab=WL_C}
N 70 56950 180 56950 {
lab=WL_C}
N 220 56930 220 56960 {
lab=WLB_C}
N 200 56930 220 56930 {
lab=WLB_C}
N 220 57080 220 57110 {
lab=VDD}
N 180 57080 180 57110 {
lab=GND}
N -30 57190 200 57190 {
lab=WLB_C}
N 180 57210 180 57220 {
lab=WL_C}
N 70 57210 180 57210 {
lab=WL_C}
N 220 57190 220 57220 {
lab=WLB_C}
N 200 57190 220 57190 {
lab=WLB_C}
N 220 57340 220 57370 {
lab=VDD}
N 180 57340 180 57370 {
lab=GND}
N -30 57410 200 57410 {
lab=WLB_C}
N 180 57430 180 57440 {
lab=WL_C}
N 70 57430 180 57430 {
lab=WL_C}
N 220 57410 220 57440 {
lab=WLB_C}
N 200 57410 220 57410 {
lab=WLB_C}
N 220 57560 220 57590 {
lab=VDD}
N 180 57560 180 57590 {
lab=GND}
N -30 57640 200 57640 {
lab=WLB_C}
N 180 57660 180 57670 {
lab=WL_C}
N 70 57660 180 57660 {
lab=WL_C}
N 220 57640 220 57670 {
lab=WLB_C}
N 200 57640 220 57640 {
lab=WLB_C}
N 220 57790 220 57820 {
lab=VDD}
N 180 57790 180 57820 {
lab=GND}
N -30 57880 200 57880 {
lab=WLB_C}
N 180 57900 180 57910 {
lab=WL_C}
N 70 57900 180 57900 {
lab=WL_C}
N 220 57880 220 57910 {
lab=WLB_C}
N 200 57880 220 57880 {
lab=WLB_C}
N 220 58030 220 58060 {
lab=VDD}
N 180 58030 180 58060 {
lab=GND}
N -30 58140 200 58140 {
lab=WLB_C}
N 180 58160 180 58170 {
lab=WL_C}
N 70 58160 180 58160 {
lab=WL_C}
N 220 58140 220 58170 {
lab=WLB_C}
N 200 58140 220 58140 {
lab=WLB_C}
N 220 58290 220 58320 {
lab=VDD}
N 180 58290 180 58320 {
lab=GND}
N -30 58360 200 58360 {
lab=WLB_C}
N 180 58380 180 58390 {
lab=WL_C}
N 70 58380 180 58380 {
lab=WL_C}
N 220 58360 220 58390 {
lab=WLB_C}
N 200 58360 220 58360 {
lab=WLB_C}
N 220 58510 220 58540 {
lab=VDD}
N 180 58510 180 58540 {
lab=GND}
N -30 58590 200 58590 {
lab=WLB_C}
N 180 58610 180 58620 {
lab=WL_C}
N 70 58610 180 58610 {
lab=WL_C}
N 220 58590 220 58620 {
lab=WLB_C}
N 200 58590 220 58590 {
lab=WLB_C}
N 220 58740 220 58770 {
lab=VDD}
N 180 58740 180 58770 {
lab=GND}
N -30 58850 200 58850 {
lab=WLB_C}
N 180 58870 180 58880 {
lab=WL_C}
N 70 58870 180 58870 {
lab=WL_C}
N 220 58850 220 58880 {
lab=WLB_C}
N 200 58850 220 58850 {
lab=WLB_C}
N 220 59000 220 59030 {
lab=VDD}
N 180 59000 180 59030 {
lab=GND}
N -30 59110 200 59110 {
lab=WLB_C}
N 180 59130 180 59140 {
lab=WL_C}
N 70 59130 180 59130 {
lab=WL_C}
N 220 59110 220 59140 {
lab=WLB_C}
N 200 59110 220 59110 {
lab=WLB_C}
N 220 59260 220 59290 {
lab=VDD}
N 180 59260 180 59290 {
lab=GND}
N -30 59330 200 59330 {
lab=WLB_C}
N 180 59350 180 59360 {
lab=WL_C}
N 70 59350 180 59350 {
lab=WL_C}
N 220 59330 220 59360 {
lab=WLB_C}
N 200 59330 220 59330 {
lab=WLB_C}
N 220 59480 220 59510 {
lab=VDD}
N 180 59480 180 59510 {
lab=GND}
N -30 59560 200 59560 {
lab=WLB_C}
N 180 59580 180 59590 {
lab=WL_C}
N 70 59580 180 59580 {
lab=WL_C}
N 220 59560 220 59590 {
lab=WLB_C}
N 200 59560 220 59560 {
lab=WLB_C}
N 180 59710 180 59740 {
lab=GND}
N 40 56060 40 59660 {
lab=BL_SEL}
N 340 56060 340 59660 {
lab=BLB_SEL}
N 40 55890 40 56060 {
lab=BL_SEL}
N 340 55890 340 56060 {
lab=BLB_SEL}
N -30 59730 200 59730 {
lab=WLB_C}
N 180 59750 180 59760 {
lab=WL_C}
N 70 59750 180 59750 {
lab=WL_C}
N 220 59730 220 59760 {
lab=WLB_C}
N 200 59730 220 59730 {
lab=WLB_C}
N 220 59880 220 59910 {
lab=VDD}
N 180 59880 180 59910 {
lab=GND}
N -30 59990 200 59990 {
lab=WLB_C}
N 180 60010 180 60020 {
lab=WL_C}
N 70 60010 180 60010 {
lab=WL_C}
N 220 59990 220 60020 {
lab=WLB_C}
N 200 59990 220 59990 {
lab=WLB_C}
N 220 60140 220 60170 {
lab=VDD}
N 180 60140 180 60170 {
lab=GND}
N -30 60210 200 60210 {
lab=WLB_C}
N 180 60230 180 60240 {
lab=WL_C}
N 70 60230 180 60230 {
lab=WL_C}
N 220 60210 220 60240 {
lab=WLB_C}
N 200 60210 220 60210 {
lab=WLB_C}
N 220 60360 220 60390 {
lab=VDD}
N 180 60360 180 60390 {
lab=GND}
N -30 60440 200 60440 {
lab=WLB_C}
N 180 60460 180 60470 {
lab=WL_C}
N 70 60460 180 60460 {
lab=WL_C}
N 220 60440 220 60470 {
lab=WLB_C}
N 200 60440 220 60440 {
lab=WLB_C}
N 220 60590 220 60620 {
lab=VDD}
N 180 60590 180 60620 {
lab=GND}
N -30 60700 200 60700 {
lab=WLB_C}
N 180 60720 180 60730 {
lab=WL_C}
N 70 60720 180 60720 {
lab=WL_C}
N 220 60700 220 60730 {
lab=WLB_C}
N 200 60700 220 60700 {
lab=WLB_C}
N 220 60850 220 60880 {
lab=VDD}
N 180 60850 180 60880 {
lab=GND}
N -30 60960 200 60960 {
lab=WLB_C}
N 180 60980 180 60990 {
lab=WL_C}
N 70 60980 180 60980 {
lab=WL_C}
N 220 60960 220 60990 {
lab=WLB_C}
N 200 60960 220 60960 {
lab=WLB_C}
N 220 61110 220 61140 {
lab=VDD}
N 180 61110 180 61140 {
lab=GND}
N -30 61180 200 61180 {
lab=WLB_C}
N 180 61200 180 61210 {
lab=WL_C}
N 70 61200 180 61200 {
lab=WL_C}
N 220 61180 220 61210 {
lab=WLB_C}
N 200 61180 220 61180 {
lab=WLB_C}
N 220 61330 220 61360 {
lab=VDD}
N 180 61330 180 61360 {
lab=GND}
N -30 61410 200 61410 {
lab=WLB_C}
N 180 61430 180 61440 {
lab=WL_C}
N 70 61430 180 61430 {
lab=WL_C}
N 220 61410 220 61440 {
lab=WLB_C}
N 200 61410 220 61410 {
lab=WLB_C}
N 220 61560 220 61590 {
lab=VDD}
N 180 61560 180 61590 {
lab=GND}
N -30 61650 200 61650 {
lab=WLB_C}
N 180 61670 180 61680 {
lab=WL_C}
N 70 61670 180 61670 {
lab=WL_C}
N 220 61650 220 61680 {
lab=WLB_C}
N 200 61650 220 61650 {
lab=WLB_C}
N 220 61800 220 61830 {
lab=VDD}
N 180 61800 180 61830 {
lab=GND}
N -30 61910 200 61910 {
lab=WLB_C}
N 180 61930 180 61940 {
lab=WL_C}
N 70 61930 180 61930 {
lab=WL_C}
N 220 61910 220 61940 {
lab=WLB_C}
N 200 61910 220 61910 {
lab=WLB_C}
N 220 62060 220 62090 {
lab=VDD}
N 180 62060 180 62090 {
lab=GND}
N -30 62130 200 62130 {
lab=WLB_C}
N 180 62150 180 62160 {
lab=WL_C}
N 70 62150 180 62150 {
lab=WL_C}
N 220 62130 220 62160 {
lab=WLB_C}
N 200 62130 220 62130 {
lab=WLB_C}
N 220 62280 220 62310 {
lab=VDD}
N 180 62280 180 62310 {
lab=GND}
N -30 62360 200 62360 {
lab=WLB_C}
N 180 62380 180 62390 {
lab=WL_C}
N 70 62380 180 62380 {
lab=WL_C}
N 220 62360 220 62390 {
lab=WLB_C}
N 200 62360 220 62360 {
lab=WLB_C}
N 220 62510 220 62540 {
lab=VDD}
N 180 62510 180 62540 {
lab=GND}
N -30 62620 200 62620 {
lab=WLB_C}
N 180 62640 180 62650 {
lab=WL_C}
N 70 62640 180 62640 {
lab=WL_C}
N 220 62620 220 62650 {
lab=WLB_C}
N 200 62620 220 62620 {
lab=WLB_C}
N 220 62770 220 62800 {
lab=VDD}
N 180 62770 180 62800 {
lab=GND}
N -30 62880 200 62880 {
lab=WLB_C}
N 180 62900 180 62910 {
lab=WL_C}
N 70 62900 180 62900 {
lab=WL_C}
N 220 62880 220 62910 {
lab=WLB_C}
N 200 62880 220 62880 {
lab=WLB_C}
N 220 63030 220 63060 {
lab=VDD}
N 180 63030 180 63060 {
lab=GND}
N -30 63100 200 63100 {
lab=WLB_C}
N 180 63120 180 63130 {
lab=WL_C}
N 70 63120 180 63120 {
lab=WL_C}
N 220 63100 220 63130 {
lab=WLB_C}
N 200 63100 220 63100 {
lab=WLB_C}
N 220 63250 220 63280 {
lab=VDD}
N 180 63250 180 63280 {
lab=GND}
N -30 63330 200 63330 {
lab=WLB_C}
N 180 63350 180 63360 {
lab=WL_C}
N 70 63350 180 63350 {
lab=WL_C}
N 220 63330 220 63360 {
lab=WLB_C}
N 200 63330 220 63330 {
lab=WLB_C}
N 180 63480 180 63510 {
lab=GND}
N 40 59830 40 63430 {
lab=BL_SEL}
N 340 59830 340 63430 {
lab=BLB_SEL}
N 40 59660 40 59830 {
lab=BL_SEL}
N 340 59660 340 59830 {
lab=BLB_SEL}
N 220 59710 250 59710 {
lab=VDD}
N -30 63500 200 63500 {
lab=WLB_C}
N 180 63520 180 63530 {
lab=WL_C}
N 70 63520 180 63520 {
lab=WL_C}
N 220 63500 220 63530 {
lab=WLB_C}
N 200 63500 220 63500 {
lab=WLB_C}
N 220 63650 220 63680 {
lab=VDD}
N 180 63650 180 63680 {
lab=GND}
N -30 63760 200 63760 {
lab=WLB_C}
N 180 63780 180 63790 {
lab=WL_C}
N 70 63780 180 63780 {
lab=WL_C}
N 220 63760 220 63790 {
lab=WLB_C}
N 200 63760 220 63760 {
lab=WLB_C}
N 220 63910 220 63940 {
lab=VDD}
N 180 63910 180 63940 {
lab=GND}
N -30 63980 200 63980 {
lab=WLB_C}
N 180 64000 180 64010 {
lab=WL_C}
N 70 64000 180 64000 {
lab=WL_C}
N 220 63980 220 64010 {
lab=WLB_C}
N 200 63980 220 63980 {
lab=WLB_C}
N 220 64130 220 64160 {
lab=VDD}
N 180 64130 180 64160 {
lab=GND}
N -30 64210 200 64210 {
lab=WLB_C}
N 180 64230 180 64240 {
lab=WL_C}
N 70 64230 180 64230 {
lab=WL_C}
N 220 64210 220 64240 {
lab=WLB_C}
N 200 64210 220 64210 {
lab=WLB_C}
N 220 64360 220 64390 {
lab=VDD}
N 180 64360 180 64390 {
lab=GND}
N -30 64470 200 64470 {
lab=WLB_C}
N 180 64490 180 64500 {
lab=WL_C}
N 70 64490 180 64490 {
lab=WL_C}
N 220 64470 220 64500 {
lab=WLB_C}
N 200 64470 220 64470 {
lab=WLB_C}
N 220 64620 220 64650 {
lab=VDD}
N 180 64620 180 64650 {
lab=GND}
N -30 64730 200 64730 {
lab=WLB_C}
N 180 64750 180 64760 {
lab=WL_C}
N 70 64750 180 64750 {
lab=WL_C}
N 220 64730 220 64760 {
lab=WLB_C}
N 200 64730 220 64730 {
lab=WLB_C}
N 220 64880 220 64910 {
lab=VDD}
N 180 64880 180 64910 {
lab=GND}
N -30 64950 200 64950 {
lab=WLB_C}
N 180 64970 180 64980 {
lab=WL_C}
N 70 64970 180 64970 {
lab=WL_C}
N 220 64950 220 64980 {
lab=WLB_C}
N 200 64950 220 64950 {
lab=WLB_C}
N 220 65100 220 65130 {
lab=VDD}
N 180 65100 180 65130 {
lab=GND}
N -30 65180 200 65180 {
lab=WLB_C}
N 180 65200 180 65210 {
lab=WL_C}
N 70 65200 180 65200 {
lab=WL_C}
N 220 65180 220 65210 {
lab=WLB_C}
N 200 65180 220 65180 {
lab=WLB_C}
N 220 65330 220 65360 {
lab=VDD}
N 180 65330 180 65360 {
lab=GND}
N -30 65420 200 65420 {
lab=WLB_C}
N 180 65440 180 65450 {
lab=WL_C}
N 70 65440 180 65440 {
lab=WL_C}
N 220 65420 220 65450 {
lab=WLB_C}
N 200 65420 220 65420 {
lab=WLB_C}
N 220 65570 220 65600 {
lab=VDD}
N 180 65570 180 65600 {
lab=GND}
N -30 65680 200 65680 {
lab=WLB_C}
N 180 65700 180 65710 {
lab=WL_C}
N 70 65700 180 65700 {
lab=WL_C}
N 220 65680 220 65710 {
lab=WLB_C}
N 200 65680 220 65680 {
lab=WLB_C}
N 220 65830 220 65860 {
lab=VDD}
N 180 65830 180 65860 {
lab=GND}
N -30 65900 200 65900 {
lab=WLB_C}
N 180 65920 180 65930 {
lab=WL_C}
N 70 65920 180 65920 {
lab=WL_C}
N 220 65900 220 65930 {
lab=WLB_C}
N 200 65900 220 65900 {
lab=WLB_C}
N 220 66050 220 66080 {
lab=VDD}
N 180 66050 180 66080 {
lab=GND}
N -30 66130 200 66130 {
lab=WLB_C}
N 180 66150 180 66160 {
lab=WL_C}
N 70 66150 180 66150 {
lab=WL_C}
N 220 66130 220 66160 {
lab=WLB_C}
N 200 66130 220 66130 {
lab=WLB_C}
N 220 66280 220 66310 {
lab=VDD}
N 180 66280 180 66310 {
lab=GND}
N -30 66390 200 66390 {
lab=WLB_C}
N 180 66410 180 66420 {
lab=WL_C}
N 70 66410 180 66410 {
lab=WL_C}
N 220 66390 220 66420 {
lab=WLB_C}
N 200 66390 220 66390 {
lab=WLB_C}
N 220 66540 220 66570 {
lab=VDD}
N 180 66540 180 66570 {
lab=GND}
N -30 66650 200 66650 {
lab=WLB_C}
N 180 66670 180 66680 {
lab=WL_C}
N 70 66670 180 66670 {
lab=WL_C}
N 220 66650 220 66680 {
lab=WLB_C}
N 200 66650 220 66650 {
lab=WLB_C}
N 220 66800 220 66830 {
lab=VDD}
N 180 66800 180 66830 {
lab=GND}
N -30 66870 200 66870 {
lab=WLB_C}
N 180 66890 180 66900 {
lab=WL_C}
N 70 66890 180 66890 {
lab=WL_C}
N 220 66870 220 66900 {
lab=WLB_C}
N 200 66870 220 66870 {
lab=WLB_C}
N 220 67020 220 67050 {
lab=VDD}
N 180 67020 180 67050 {
lab=GND}
N -30 67100 200 67100 {
lab=WLB_C}
N 180 67120 180 67130 {
lab=WL_C}
N 70 67120 180 67120 {
lab=WL_C}
N 220 67100 220 67130 {
lab=WLB_C}
N 200 67100 220 67100 {
lab=WLB_C}
N 220 67250 220 67280 {
lab=VDD}
N 180 67250 180 67280 {
lab=GND}
N 40 63600 40 67200 {
lab=BL_SEL}
N 340 63600 340 67200 {
lab=BLB_SEL}
N 40 63430 40 63600 {
lab=BL_SEL}
N 340 63430 340 63600 {
lab=BLB_SEL}
N 220 63480 240 63480 {
lab=VDD}
N 220 55940 250 55940 {
lab=VDD}
N 220 52170 240 52170 {
lab=VDD}
N 220 48400 250 48400 {
lab=VDD}
N 220 44630 240 44630 {
lab=VDD}
N 220 40860 250 40860 {
lab=VDD}
N 220 37090 250 37090 {
lab=VDD}
N 220 29550 250 29550 {
lab=VDD}
N 220 25780 250 25780 {
lab=VDD}
N 220 18240 260 18240 {
lab=VDD}
N 220 14470 250 14470 {
lab=VDD}
N 220 10700 250 10700 {
lab=VDD}
N 40 67200 40 67540 {
lab=BL_SEL}
N 40 67540 160 67540 {
lab=BL_SEL}
N 340 67200 340 67530 {
lab=BLB_SEL}
N 220 67530 340 67530 {
lab=BLB_SEL}
N -1710 860 -1710 900 {
lab=WLB_C}
N -1710 960 -1710 1000 {
lab=GND}
N -1480 840 -1480 900 {
lab=WL_C}
N -1480 960 -1480 1000 {
lab=GND}
N 220 490 250 490 {
lab=VDD}
N 220 6930 250 6930 {
lab=VDD}
N 220 22010 250 22010 {
lab=VDD}
N 220 33320 240 33320 {
lab=VDD}
C {SRAM/PIM_NOR.sym} 190 -250 0 0 {name=x1}
C {SRAM/PIM_NOR.sym} 190 -10 0 0 {name=x2}
C {SRAM/PIM_NOR.sym} 190 200 0 0 {name=x3}
C {sky130_fd_pr/nfet_01v8.sym} 190 67590 3 0 {name=M1
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 190 67450 1 0 {name=M3
L=0.15
W=0.42
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -50 -350 0 0 {name=l7 sig_type=std_logic lab=WLB_A}
C {devices/lab_pin.sym} -50 -330 0 0 {name=l8 sig_type=std_logic lab=WL_A}
C {devices/lab_pin.sym} -20 -100 0 0 {name=l9 sig_type=std_logic lab=WLB_B}
C {devices/lab_pin.sym} -20 -80 0 0 {name=l10 sig_type=std_logic lab=WL_B}
C {devices/lab_pin.sym} -30 110 0 0 {name=l11 sig_type=std_logic lab=WLB_D}
C {devices/lab_pin.sym} 70 130 0 0 {name=l12 sig_type=std_logic lab=WL_D}
C {devices/lab_pin.sym} -70 70 0 0 {name=l13 sig_type=std_logic lab=BL_SEL}
C {devices/lab_pin.sym} 450 70 2 0 {name=l14 sig_type=std_logic lab=BLB_SEL}
C {devices/vsource.sym} -700 -170 0 0 {name=VDD value=1.8}
C {sky130_fd_pr/nfet_01v8.sym} -480 -220 3 0 {name=M2
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -480 -360 1 0 {name=M4
L=0.15
W=0.42
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 190 67410 1 0 {name=l19 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 190 67630 3 0 {name=l20 sig_type=std_logic lab=SELB}
C {devices/lab_pin.sym} -410 -280 2 0 {name=l21 sig_type=std_logic lab=BL_SEL}
C {devices/lab_pin.sym} -560 -280 0 0 {name=l22 sig_type=std_logic lab=BL}
C {sky130_fd_pr/nfet_01v8.sym} -480 110 3 0 {name=M5
L=0.15
W=0.36
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -480 -30 1 0 {name=M6
L=0.15
W=0.42
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -410 50 2 0 {name=l23 sig_type=std_logic lab=BLB_SEL}
C {devices/lab_pin.sym} -560 50 0 0 {name=l24 sig_type=std_logic lab=BLB}
C {devices/vsource.sym} -1140 260 0 0 {name=v1 value="pulse(1.8 0 5ns 30ps 30ps 5ns )"}
C {devices/lab_pin.sym} -1140 230 0 0 {name=l28 sig_type=std_logic lab=BL}
C {devices/vsource.sym} -870 260 0 0 {name=v3 value="pulse(0 1.8 5ns 30ps 30ps 5ns )"}
C {devices/lab_pin.sym} -870 230 0 0 {name=l30 sig_type=std_logic lab=BLB}
C {devices/vsource.sym} -1700 590 0 0 {name=v2 value="pulse(0 2 5ns 30ps 30ps 5ns  )"}
C {devices/lab_pin.sym} -1700 520 1 0 {name=l29 sig_type=std_logic lab=WL_A}
C {devices/vsource.sym} -1470 590 0 0 {name=v4 value="pulse(0 2 5ns 30ps 30ps 5ns 40ns  )"}
C {devices/lab_pin.sym} -1470 500 1 0 {name=l32 sig_type=std_logic lab=WLB_A}
C {devices/vsource.sym} -1210 590 0 0 {name=v5 value="pulse(0 2 15ns 30ps 30ps 5ns  )"}
C {devices/lab_pin.sym} -1210 520 1 0 {name=l34 sig_type=std_logic lab=WL_B}
C {devices/vsource.sym} -980 590 0 0 {name=v6 value="pulse(0 2 15ns 30ps 30ps 5ns 30ns  )"}
C {devices/lab_pin.sym} -980 500 1 0 {name=l36 sig_type=std_logic lab=WLB_B}
C {devices/vsource.sym} -740 590 0 0 {name=v7 value="pulse(0 2 25ns 30ps 30ps 5ns  )"}
C {devices/lab_pin.sym} -740 520 1 0 {name=l38 sig_type=std_logic lab=WLB_D}
C {devices/vsource.sym} -510 590 0 0 {name=v8 value="pulse(0 2 25ns 30ps 30ps 5ns 20ns  )"}
C {devices/lab_pin.sym} -510 500 1 0 {name=l40 sig_type=std_logic lab=WL_D}
C {devices/vsource.sym} -1090 950 0 0 {name=v9 value="pulse(1.8 0 30ns 30ps 30ps )"}
C {devices/lab_pin.sym} -1090 920 0 0 {name=l41 sig_type=std_logic lab=SEL}
C {devices/vsource.sym} -820 950 0 0 {name=v10 value="pulse(0 1.8 30ns 30ps 30ps )"}
C {devices/lab_pin.sym} -820 920 0 0 {name=l42 sig_type=std_logic lab=SELB}
C {devices/code.sym} 420 -640 0 0 {name=spice only_toplevel=false value=.tran 1n 60n 0n

.save all}
C {devices/code.sym} 420 -840 0 0 {name=TT_MC_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.options wnflag=1
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/models/corners/tt/nonfet.spice
* Mismatch parameters
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/models/r+c/res_typical__cap_typical.spice
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/models/corners/tt/specialized_cells.spice
* All models
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/models/all.spice
* Corner
.include /pdk/open_pdks/sources/sky130-pdk/libraries/sky130_fd_pr/latest/models/corners/tt/rf.spice
"}
C {devices/lab_pin.sym} -480 150 3 0 {name=l45 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} -480 -180 3 0 {name=l46 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} -480 -400 1 0 {name=l47 sig_type=std_logic lab=SELB}
C {devices/lab_pin.sym} -480 -70 1 0 {name=l48 sig_type=std_logic lab=SELB}
C {devices/gnd.sym} -700 -120 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} -870 310 0 0 {name=l2 lab=GND}
C {devices/gnd.sym} -1140 310 0 0 {name=l3 lab=GND}
C {devices/gnd.sym} -510 660 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} -740 660 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} -980 660 0 0 {name=l6 lab=GND}
C {devices/gnd.sym} -1210 660 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} -1470 660 0 0 {name=l17 lab=GND}
C {devices/gnd.sym} -1700 660 0 0 {name=l18 lab=GND}
C {devices/gnd.sym} -820 1000 0 0 {name=l25 lab=GND}
C {devices/gnd.sym} -1090 1000 0 0 {name=l26 lab=GND}
C {devices/vdd.sym} -400 -330 1 0 {name=l15 lab=VDD}
C {devices/vdd.sym} -700 -230 0 0 {name=l27 lab=VDD}
C {devices/gnd.sym} -390 -260 3 0 {name=l31 lab=GND}
C {devices/gnd.sym} -400 70 3 0 {name=l33 lab=GND}
C {devices/vdd.sym} -390 0 1 0 {name=l35 lab=VDD}
C {devices/vdd.sym} 260 67480 1 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 260 67550 3 0 {name=l39 lab=GND}
C {devices/vdd.sym} 220 -150 2 0 {name=l43 lab=VDD}
C {devices/vdd.sym} 220 70 2 0 {name=l44 lab=VDD}
C {devices/vdd.sym} 220 290 2 0 {name=l49 lab=VDD}
C {devices/gnd.sym} 180 -160 0 0 {name=l50 lab=GND}
C {devices/gnd.sym} 180 70 0 0 {name=l51 lab=GND}
C {devices/gnd.sym} 180 290 0 0 {name=l52 lab=GND}
C {SRAM/PIM_NOR.sym} 190 430 0 0 {name=x4}
C {devices/lab_pin.sym} -30 340 0 0 {name=l53 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 360 0 0 {name=l54 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 490 2 0 {name=l55 lab=VDD}
C {devices/gnd.sym} 180 520 0 0 {name=l56 lab=GND}
C {SRAM/PIM_NOR.sym} 190 640 0 0 {name=x6}
C {devices/lab_pin.sym} -30 550 0 0 {name=l61 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 570 0 0 {name=l62 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 730 2 0 {name=l63 lab=VDD}
C {devices/gnd.sym} 180 730 0 0 {name=l64 lab=GND}
C {SRAM/PIM_NOR.sym} 190 860 0 0 {name=x7}
C {devices/lab_pin.sym} -30 770 0 0 {name=l65 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 790 0 0 {name=l66 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 950 2 0 {name=l67 lab=VDD}
C {devices/gnd.sym} 180 950 0 0 {name=l68 lab=GND}
C {SRAM/PIM_NOR.sym} 190 1130 0 0 {name=x8}
C {devices/lab_pin.sym} -30 1040 0 0 {name=l69 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 1060 0 0 {name=l70 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 1220 2 0 {name=l71 lab=VDD}
C {devices/gnd.sym} 180 1220 0 0 {name=l72 lab=GND}
C {SRAM/PIM_NOR.sym} 190 1390 0 0 {name=x9}
C {devices/lab_pin.sym} -30 1300 0 0 {name=l73 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 1320 0 0 {name=l74 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 1480 2 0 {name=l75 lab=VDD}
C {devices/gnd.sym} 180 1480 0 0 {name=l76 lab=GND}
C {SRAM/PIM_NOR.sym} 190 1610 0 0 {name=x10}
C {devices/lab_pin.sym} -30 1520 0 0 {name=l77 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 1540 0 0 {name=l78 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 1700 2 0 {name=l79 lab=VDD}
C {devices/gnd.sym} 180 1700 0 0 {name=l80 lab=GND}
C {SRAM/PIM_NOR.sym} 190 1840 0 0 {name=x11}
C {devices/lab_pin.sym} -30 1750 0 0 {name=l81 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 1770 0 0 {name=l82 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 1930 2 0 {name=l83 lab=VDD}
C {devices/gnd.sym} 180 1930 0 0 {name=l84 lab=GND}
C {SRAM/PIM_NOR.sym} 190 2100 0 0 {name=x5}
C {devices/lab_pin.sym} -30 2010 0 0 {name=l57 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 2030 0 0 {name=l58 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 2190 2 0 {name=l59 lab=VDD}
C {devices/gnd.sym} 180 2190 0 0 {name=l60 lab=GND}
C {SRAM/PIM_NOR.sym} 190 2360 0 0 {name=x12}
C {devices/lab_pin.sym} -30 2270 0 0 {name=l85 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 2290 0 0 {name=l86 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 2450 2 0 {name=l87 lab=VDD}
C {devices/gnd.sym} 180 2450 0 0 {name=l88 lab=GND}
C {SRAM/PIM_NOR.sym} 190 2580 0 0 {name=x13}
C {devices/lab_pin.sym} -30 2490 0 0 {name=l89 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 2510 0 0 {name=l90 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 2670 2 0 {name=l91 lab=VDD}
C {devices/gnd.sym} 180 2670 0 0 {name=l92 lab=GND}
C {SRAM/PIM_NOR.sym} 190 2810 0 0 {name=x14}
C {devices/lab_pin.sym} -30 2720 0 0 {name=l93 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 2740 0 0 {name=l94 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 2900 2 0 {name=l95 lab=VDD}
C {devices/gnd.sym} 180 2900 0 0 {name=l96 lab=GND}
C {SRAM/PIM_NOR.sym} 190 3270 0 0 {name=x23}
C {devices/lab_pin.sym} -30 3180 0 0 {name=l129 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 3200 0 0 {name=l130 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 3360 2 0 {name=l131 lab=VDD}
C {devices/gnd.sym} 180 3360 0 0 {name=l132 lab=GND}
C {SRAM/PIM_NOR.sym} 190 3530 0 0 {name=x24}
C {devices/lab_pin.sym} -30 3440 0 0 {name=l133 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 3460 0 0 {name=l134 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 3620 2 0 {name=l135 lab=VDD}
C {devices/gnd.sym} 180 3620 0 0 {name=l136 lab=GND}
C {SRAM/PIM_NOR.sym} 190 3750 0 0 {name=x25}
C {devices/lab_pin.sym} -30 3660 0 0 {name=l137 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 3680 0 0 {name=l138 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 3840 2 0 {name=l139 lab=VDD}
C {devices/gnd.sym} 180 3840 0 0 {name=l140 lab=GND}
C {SRAM/PIM_NOR.sym} 190 3980 0 0 {name=x26}
C {devices/lab_pin.sym} -30 3890 0 0 {name=l141 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 3910 0 0 {name=l142 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 4070 2 0 {name=l143 lab=VDD}
C {devices/gnd.sym} 180 4070 0 0 {name=l144 lab=GND}
C {SRAM/PIM_NOR.sym} 190 4240 0 0 {name=x27}
C {devices/lab_pin.sym} -30 4150 0 0 {name=l145 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 4170 0 0 {name=l146 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 4330 2 0 {name=l147 lab=VDD}
C {devices/gnd.sym} 180 4330 0 0 {name=l148 lab=GND}
C {SRAM/PIM_NOR.sym} 190 4500 0 0 {name=x28}
C {devices/lab_pin.sym} -30 4410 0 0 {name=l149 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 4430 0 0 {name=l150 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 4590 2 0 {name=l151 lab=VDD}
C {devices/gnd.sym} 180 4590 0 0 {name=l152 lab=GND}
C {SRAM/PIM_NOR.sym} 190 4720 0 0 {name=x29}
C {devices/lab_pin.sym} -30 4630 0 0 {name=l153 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 4650 0 0 {name=l154 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 4810 2 0 {name=l155 lab=VDD}
C {devices/gnd.sym} 180 4810 0 0 {name=l156 lab=GND}
C {SRAM/PIM_NOR.sym} 190 4950 0 0 {name=x30}
C {devices/lab_pin.sym} -30 4860 0 0 {name=l157 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 4880 0 0 {name=l158 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 5040 2 0 {name=l159 lab=VDD}
C {devices/gnd.sym} 180 5040 0 0 {name=l160 lab=GND}
C {SRAM/PIM_NOR.sym} 190 5190 0 0 {name=x31}
C {devices/lab_pin.sym} -30 5100 0 0 {name=l161 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 5120 0 0 {name=l162 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 5280 2 0 {name=l163 lab=VDD}
C {devices/gnd.sym} 180 5280 0 0 {name=l164 lab=GND}
C {SRAM/PIM_NOR.sym} 190 5450 0 0 {name=x32}
C {devices/lab_pin.sym} -30 5360 0 0 {name=l165 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 5380 0 0 {name=l166 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 5540 2 0 {name=l167 lab=VDD}
C {devices/gnd.sym} 180 5540 0 0 {name=l168 lab=GND}
C {SRAM/PIM_NOR.sym} 190 5670 0 0 {name=x33}
C {devices/lab_pin.sym} -30 5580 0 0 {name=l169 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 5600 0 0 {name=l170 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 5760 2 0 {name=l171 lab=VDD}
C {devices/gnd.sym} 180 5760 0 0 {name=l172 lab=GND}
C {SRAM/PIM_NOR.sym} 190 5900 0 0 {name=x34}
C {devices/lab_pin.sym} -30 5810 0 0 {name=l173 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 5830 0 0 {name=l174 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 5990 2 0 {name=l175 lab=VDD}
C {devices/gnd.sym} 180 5990 0 0 {name=l176 lab=GND}
C {SRAM/PIM_NOR.sym} 190 6160 0 0 {name=x35}
C {devices/lab_pin.sym} -30 6070 0 0 {name=l177 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 6090 0 0 {name=l178 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 6250 2 0 {name=l179 lab=VDD}
C {devices/gnd.sym} 180 6250 0 0 {name=l180 lab=GND}
C {SRAM/PIM_NOR.sym} 190 6420 0 0 {name=x36}
C {devices/lab_pin.sym} -30 6330 0 0 {name=l181 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 6350 0 0 {name=l182 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 6510 2 0 {name=l183 lab=VDD}
C {devices/gnd.sym} 180 6510 0 0 {name=l184 lab=GND}
C {SRAM/PIM_NOR.sym} 190 6640 0 0 {name=x37}
C {devices/lab_pin.sym} -30 6550 0 0 {name=l185 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 6570 0 0 {name=l186 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 6730 2 0 {name=l187 lab=VDD}
C {devices/gnd.sym} 180 6730 0 0 {name=l188 lab=GND}
C {SRAM/PIM_NOR.sym} 190 6870 0 0 {name=x38}
C {devices/lab_pin.sym} -30 6780 0 0 {name=l189 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 6800 0 0 {name=l190 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 6930 2 0 {name=l191 lab=VDD}
C {devices/gnd.sym} 180 6960 0 0 {name=l192 lab=GND}
C {SRAM/PIM_NOR.sym} 190 7040 0 0 {name=x47}
C {devices/lab_pin.sym} -30 6950 0 0 {name=l225 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 6970 0 0 {name=l226 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 7130 2 0 {name=l227 lab=VDD}
C {devices/gnd.sym} 180 7130 0 0 {name=l228 lab=GND}
C {SRAM/PIM_NOR.sym} 190 7300 0 0 {name=x48}
C {devices/lab_pin.sym} -30 7210 0 0 {name=l229 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 7230 0 0 {name=l230 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 7390 2 0 {name=l231 lab=VDD}
C {devices/gnd.sym} 180 7390 0 0 {name=l232 lab=GND}
C {SRAM/PIM_NOR.sym} 190 7520 0 0 {name=x49}
C {devices/lab_pin.sym} -30 7430 0 0 {name=l233 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 7450 0 0 {name=l234 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 7610 2 0 {name=l235 lab=VDD}
C {devices/gnd.sym} 180 7610 0 0 {name=l236 lab=GND}
C {SRAM/PIM_NOR.sym} 190 7750 0 0 {name=x50}
C {devices/lab_pin.sym} -30 7660 0 0 {name=l237 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 7680 0 0 {name=l238 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 7840 2 0 {name=l239 lab=VDD}
C {devices/gnd.sym} 180 7840 0 0 {name=l240 lab=GND}
C {SRAM/PIM_NOR.sym} 190 8010 0 0 {name=x51}
C {devices/lab_pin.sym} -30 7920 0 0 {name=l241 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 7940 0 0 {name=l242 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 8100 2 0 {name=l243 lab=VDD}
C {devices/gnd.sym} 180 8100 0 0 {name=l244 lab=GND}
C {SRAM/PIM_NOR.sym} 190 8270 0 0 {name=x52}
C {devices/lab_pin.sym} -30 8180 0 0 {name=l245 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 8200 0 0 {name=l246 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 8360 2 0 {name=l247 lab=VDD}
C {devices/gnd.sym} 180 8360 0 0 {name=l248 lab=GND}
C {SRAM/PIM_NOR.sym} 190 8490 0 0 {name=x53}
C {devices/lab_pin.sym} -30 8400 0 0 {name=l249 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 8420 0 0 {name=l250 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 8580 2 0 {name=l251 lab=VDD}
C {devices/gnd.sym} 180 8580 0 0 {name=l252 lab=GND}
C {SRAM/PIM_NOR.sym} 190 8720 0 0 {name=x54}
C {devices/lab_pin.sym} -30 8630 0 0 {name=l253 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 8650 0 0 {name=l254 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 8810 2 0 {name=l255 lab=VDD}
C {devices/gnd.sym} 180 8810 0 0 {name=l256 lab=GND}
C {SRAM/PIM_NOR.sym} 190 8960 0 0 {name=x55}
C {devices/lab_pin.sym} -30 8870 0 0 {name=l257 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 8890 0 0 {name=l258 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 9050 2 0 {name=l259 lab=VDD}
C {devices/gnd.sym} 180 9050 0 0 {name=l260 lab=GND}
C {SRAM/PIM_NOR.sym} 190 9220 0 0 {name=x56}
C {devices/lab_pin.sym} -30 9130 0 0 {name=l261 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 9150 0 0 {name=l262 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 9310 2 0 {name=l263 lab=VDD}
C {devices/gnd.sym} 180 9310 0 0 {name=l264 lab=GND}
C {SRAM/PIM_NOR.sym} 190 9440 0 0 {name=x57}
C {devices/lab_pin.sym} -30 9350 0 0 {name=l265 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 9370 0 0 {name=l266 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 9530 2 0 {name=l267 lab=VDD}
C {devices/gnd.sym} 180 9530 0 0 {name=l268 lab=GND}
C {SRAM/PIM_NOR.sym} 190 9670 0 0 {name=x58}
C {devices/lab_pin.sym} -30 9580 0 0 {name=l269 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 9600 0 0 {name=l270 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 9760 2 0 {name=l271 lab=VDD}
C {devices/gnd.sym} 180 9760 0 0 {name=l272 lab=GND}
C {SRAM/PIM_NOR.sym} 190 9930 0 0 {name=x59}
C {devices/lab_pin.sym} -30 9840 0 0 {name=l273 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 9860 0 0 {name=l274 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 10020 2 0 {name=l275 lab=VDD}
C {devices/gnd.sym} 180 10020 0 0 {name=l276 lab=GND}
C {SRAM/PIM_NOR.sym} 190 10190 0 0 {name=x60}
C {devices/lab_pin.sym} -30 10100 0 0 {name=l277 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 10120 0 0 {name=l278 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 10280 2 0 {name=l279 lab=VDD}
C {devices/gnd.sym} 180 10280 0 0 {name=l280 lab=GND}
C {SRAM/PIM_NOR.sym} 190 10410 0 0 {name=x61}
C {devices/lab_pin.sym} -30 10320 0 0 {name=l281 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 10340 0 0 {name=l282 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 10500 2 0 {name=l283 lab=VDD}
C {devices/gnd.sym} 180 10500 0 0 {name=l284 lab=GND}
C {SRAM/PIM_NOR.sym} 190 10640 0 0 {name=x62}
C {devices/lab_pin.sym} -30 10550 0 0 {name=l285 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 10570 0 0 {name=l286 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 10700 2 0 {name=l287 lab=VDD}
C {devices/gnd.sym} 180 10730 0 0 {name=l288 lab=GND}
C {SRAM/PIM_NOR.sym} 190 10810 0 0 {name=x63}
C {devices/lab_pin.sym} -30 10720 0 0 {name=l289 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 10740 0 0 {name=l290 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 10900 2 0 {name=l291 lab=VDD}
C {devices/gnd.sym} 180 10900 0 0 {name=l292 lab=GND}
C {SRAM/PIM_NOR.sym} 190 11070 0 0 {name=x64}
C {devices/lab_pin.sym} -30 10980 0 0 {name=l293 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 11000 0 0 {name=l294 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 11160 2 0 {name=l295 lab=VDD}
C {devices/gnd.sym} 180 11160 0 0 {name=l296 lab=GND}
C {SRAM/PIM_NOR.sym} 190 11290 0 0 {name=x65}
C {devices/lab_pin.sym} -30 11200 0 0 {name=l297 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 11220 0 0 {name=l298 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 11380 2 0 {name=l299 lab=VDD}
C {devices/gnd.sym} 180 11380 0 0 {name=l300 lab=GND}
C {SRAM/PIM_NOR.sym} 190 11520 0 0 {name=x66}
C {devices/lab_pin.sym} -30 11430 0 0 {name=l301 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 11450 0 0 {name=l302 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 11610 2 0 {name=l303 lab=VDD}
C {devices/gnd.sym} 180 11610 0 0 {name=l304 lab=GND}
C {SRAM/PIM_NOR.sym} 190 11780 0 0 {name=x67}
C {devices/lab_pin.sym} -30 11690 0 0 {name=l305 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 11710 0 0 {name=l306 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 11870 2 0 {name=l307 lab=VDD}
C {devices/gnd.sym} 180 11870 0 0 {name=l308 lab=GND}
C {SRAM/PIM_NOR.sym} 190 12040 0 0 {name=x68}
C {devices/lab_pin.sym} -30 11950 0 0 {name=l309 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 11970 0 0 {name=l310 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 12130 2 0 {name=l311 lab=VDD}
C {devices/gnd.sym} 180 12130 0 0 {name=l312 lab=GND}
C {SRAM/PIM_NOR.sym} 190 12260 0 0 {name=x69}
C {devices/lab_pin.sym} -30 12170 0 0 {name=l313 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 12190 0 0 {name=l314 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 12350 2 0 {name=l315 lab=VDD}
C {devices/gnd.sym} 180 12350 0 0 {name=l316 lab=GND}
C {SRAM/PIM_NOR.sym} 190 12490 0 0 {name=x70}
C {devices/lab_pin.sym} -30 12400 0 0 {name=l317 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 12420 0 0 {name=l318 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 12580 2 0 {name=l319 lab=VDD}
C {devices/gnd.sym} 180 12580 0 0 {name=l320 lab=GND}
C {SRAM/PIM_NOR.sym} 190 12730 0 0 {name=x71}
C {devices/lab_pin.sym} -30 12640 0 0 {name=l321 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 12660 0 0 {name=l322 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 12820 2 0 {name=l323 lab=VDD}
C {devices/gnd.sym} 180 12820 0 0 {name=l324 lab=GND}
C {SRAM/PIM_NOR.sym} 190 12990 0 0 {name=x72}
C {devices/lab_pin.sym} -30 12900 0 0 {name=l325 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 12920 0 0 {name=l326 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 13080 2 0 {name=l327 lab=VDD}
C {devices/gnd.sym} 180 13080 0 0 {name=l328 lab=GND}
C {SRAM/PIM_NOR.sym} 190 13210 0 0 {name=x73}
C {devices/lab_pin.sym} -30 13120 0 0 {name=l329 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 13140 0 0 {name=l330 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 13300 2 0 {name=l331 lab=VDD}
C {devices/gnd.sym} 180 13300 0 0 {name=l332 lab=GND}
C {SRAM/PIM_NOR.sym} 190 13440 0 0 {name=x74}
C {devices/lab_pin.sym} -30 13350 0 0 {name=l333 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 13370 0 0 {name=l334 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 13530 2 0 {name=l335 lab=VDD}
C {devices/gnd.sym} 180 13530 0 0 {name=l336 lab=GND}
C {SRAM/PIM_NOR.sym} 190 13700 0 0 {name=x75}
C {devices/lab_pin.sym} -30 13610 0 0 {name=l337 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 13630 0 0 {name=l338 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 13790 2 0 {name=l339 lab=VDD}
C {devices/gnd.sym} 180 13790 0 0 {name=l340 lab=GND}
C {SRAM/PIM_NOR.sym} 190 13960 0 0 {name=x76}
C {devices/lab_pin.sym} -30 13870 0 0 {name=l341 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 13890 0 0 {name=l342 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 14050 2 0 {name=l343 lab=VDD}
C {devices/gnd.sym} 180 14050 0 0 {name=l344 lab=GND}
C {SRAM/PIM_NOR.sym} 190 14180 0 0 {name=x77}
C {devices/lab_pin.sym} -30 14090 0 0 {name=l345 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 14110 0 0 {name=l346 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 14270 2 0 {name=l347 lab=VDD}
C {devices/gnd.sym} 180 14270 0 0 {name=l348 lab=GND}
C {SRAM/PIM_NOR.sym} 190 14410 0 0 {name=x78}
C {devices/lab_pin.sym} -30 14320 0 0 {name=l349 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 14340 0 0 {name=l350 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 14470 2 0 {name=l351 lab=VDD}
C {devices/gnd.sym} 180 14500 0 0 {name=l352 lab=GND}
C {SRAM/PIM_NOR.sym} 190 14580 0 0 {name=x79}
C {devices/lab_pin.sym} -30 14490 0 0 {name=l353 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 14510 0 0 {name=l354 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 14670 2 0 {name=l355 lab=VDD}
C {devices/gnd.sym} 180 14670 0 0 {name=l356 lab=GND}
C {SRAM/PIM_NOR.sym} 190 14840 0 0 {name=x80}
C {devices/lab_pin.sym} -30 14750 0 0 {name=l357 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 14770 0 0 {name=l358 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 14930 2 0 {name=l359 lab=VDD}
C {devices/gnd.sym} 180 14930 0 0 {name=l360 lab=GND}
C {SRAM/PIM_NOR.sym} 190 15060 0 0 {name=x81}
C {devices/lab_pin.sym} -30 14970 0 0 {name=l361 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 14990 0 0 {name=l362 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 15150 2 0 {name=l363 lab=VDD}
C {devices/gnd.sym} 180 15150 0 0 {name=l364 lab=GND}
C {SRAM/PIM_NOR.sym} 190 15290 0 0 {name=x82}
C {devices/lab_pin.sym} -30 15200 0 0 {name=l365 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 15220 0 0 {name=l366 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 15380 2 0 {name=l367 lab=VDD}
C {devices/gnd.sym} 180 15380 0 0 {name=l368 lab=GND}
C {SRAM/PIM_NOR.sym} 190 15550 0 0 {name=x83}
C {devices/lab_pin.sym} -30 15460 0 0 {name=l369 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 15480 0 0 {name=l370 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 15640 2 0 {name=l371 lab=VDD}
C {devices/gnd.sym} 180 15640 0 0 {name=l372 lab=GND}
C {SRAM/PIM_NOR.sym} 190 15810 0 0 {name=x84}
C {devices/lab_pin.sym} -30 15720 0 0 {name=l373 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 15740 0 0 {name=l374 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 15900 2 0 {name=l375 lab=VDD}
C {devices/gnd.sym} 180 15900 0 0 {name=l376 lab=GND}
C {SRAM/PIM_NOR.sym} 190 16030 0 0 {name=x85}
C {devices/lab_pin.sym} -30 15940 0 0 {name=l377 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 15960 0 0 {name=l378 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 16120 2 0 {name=l379 lab=VDD}
C {devices/gnd.sym} 180 16120 0 0 {name=l380 lab=GND}
C {SRAM/PIM_NOR.sym} 190 16260 0 0 {name=x86}
C {devices/lab_pin.sym} -30 16170 0 0 {name=l381 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 16190 0 0 {name=l382 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 16350 2 0 {name=l383 lab=VDD}
C {devices/gnd.sym} 180 16350 0 0 {name=l384 lab=GND}
C {SRAM/PIM_NOR.sym} 190 16500 0 0 {name=x87}
C {devices/lab_pin.sym} -30 16410 0 0 {name=l385 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 16430 0 0 {name=l386 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 16590 2 0 {name=l387 lab=VDD}
C {devices/gnd.sym} 180 16590 0 0 {name=l388 lab=GND}
C {SRAM/PIM_NOR.sym} 190 16760 0 0 {name=x88}
C {devices/lab_pin.sym} -30 16670 0 0 {name=l389 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 16690 0 0 {name=l390 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 16850 2 0 {name=l391 lab=VDD}
C {devices/gnd.sym} 180 16850 0 0 {name=l392 lab=GND}
C {SRAM/PIM_NOR.sym} 190 16980 0 0 {name=x89}
C {devices/lab_pin.sym} -30 16890 0 0 {name=l393 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 16910 0 0 {name=l394 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 17070 2 0 {name=l395 lab=VDD}
C {devices/gnd.sym} 180 17070 0 0 {name=l396 lab=GND}
C {SRAM/PIM_NOR.sym} 190 17210 0 0 {name=x90}
C {devices/lab_pin.sym} -30 17120 0 0 {name=l397 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 17140 0 0 {name=l398 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 17300 2 0 {name=l399 lab=VDD}
C {devices/gnd.sym} 180 17300 0 0 {name=l400 lab=GND}
C {SRAM/PIM_NOR.sym} 190 17470 0 0 {name=x91}
C {devices/lab_pin.sym} -30 17380 0 0 {name=l401 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 17400 0 0 {name=l402 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 17560 2 0 {name=l403 lab=VDD}
C {devices/gnd.sym} 180 17560 0 0 {name=l404 lab=GND}
C {SRAM/PIM_NOR.sym} 190 17730 0 0 {name=x92}
C {devices/lab_pin.sym} -30 17640 0 0 {name=l405 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 17660 0 0 {name=l406 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 17820 2 0 {name=l407 lab=VDD}
C {devices/gnd.sym} 180 17820 0 0 {name=l408 lab=GND}
C {SRAM/PIM_NOR.sym} 190 17950 0 0 {name=x93}
C {devices/lab_pin.sym} -30 17860 0 0 {name=l409 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 17880 0 0 {name=l410 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 18040 2 0 {name=l411 lab=VDD}
C {devices/gnd.sym} 180 18040 0 0 {name=l412 lab=GND}
C {SRAM/PIM_NOR.sym} 190 18180 0 0 {name=x94}
C {devices/lab_pin.sym} -30 18090 0 0 {name=l413 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 18110 0 0 {name=l414 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 260 18240 2 0 {name=l415 lab=VDD}
C {devices/gnd.sym} 180 18270 0 0 {name=l416 lab=GND}
C {SRAM/PIM_NOR.sym} 190 18350 0 0 {name=x95}
C {devices/lab_pin.sym} -30 18260 0 0 {name=l417 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 18280 0 0 {name=l418 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 18440 2 0 {name=l419 lab=VDD}
C {devices/gnd.sym} 180 18440 0 0 {name=l420 lab=GND}
C {SRAM/PIM_NOR.sym} 190 18610 0 0 {name=x96}
C {devices/lab_pin.sym} -30 18520 0 0 {name=l421 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 18540 0 0 {name=l422 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 18700 2 0 {name=l423 lab=VDD}
C {devices/gnd.sym} 180 18700 0 0 {name=l424 lab=GND}
C {SRAM/PIM_NOR.sym} 190 18830 0 0 {name=x97}
C {devices/lab_pin.sym} -30 18740 0 0 {name=l425 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 18760 0 0 {name=l426 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 18920 2 0 {name=l427 lab=VDD}
C {devices/gnd.sym} 180 18920 0 0 {name=l428 lab=GND}
C {SRAM/PIM_NOR.sym} 190 19060 0 0 {name=x98}
C {devices/lab_pin.sym} -30 18970 0 0 {name=l429 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 18990 0 0 {name=l430 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 19150 2 0 {name=l431 lab=VDD}
C {devices/gnd.sym} 180 19150 0 0 {name=l432 lab=GND}
C {SRAM/PIM_NOR.sym} 190 19320 0 0 {name=x99}
C {devices/lab_pin.sym} -30 19230 0 0 {name=l433 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 19250 0 0 {name=l434 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 19410 2 0 {name=l435 lab=VDD}
C {devices/gnd.sym} 180 19410 0 0 {name=l436 lab=GND}
C {SRAM/PIM_NOR.sym} 190 19580 0 0 {name=x100}
C {devices/lab_pin.sym} -30 19490 0 0 {name=l437 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 19510 0 0 {name=l438 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 19670 2 0 {name=l439 lab=VDD}
C {devices/gnd.sym} 180 19670 0 0 {name=l440 lab=GND}
C {SRAM/PIM_NOR.sym} 190 19800 0 0 {name=x101}
C {devices/lab_pin.sym} -30 19710 0 0 {name=l441 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 19730 0 0 {name=l442 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 19890 2 0 {name=l443 lab=VDD}
C {devices/gnd.sym} 180 19890 0 0 {name=l444 lab=GND}
C {SRAM/PIM_NOR.sym} 190 20030 0 0 {name=x102}
C {devices/lab_pin.sym} -30 19940 0 0 {name=l445 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 19960 0 0 {name=l446 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 20120 2 0 {name=l447 lab=VDD}
C {devices/gnd.sym} 180 20120 0 0 {name=l448 lab=GND}
C {SRAM/PIM_NOR.sym} 190 20270 0 0 {name=x103}
C {devices/lab_pin.sym} -30 20180 0 0 {name=l449 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 20200 0 0 {name=l450 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 20360 2 0 {name=l451 lab=VDD}
C {devices/gnd.sym} 180 20360 0 0 {name=l452 lab=GND}
C {SRAM/PIM_NOR.sym} 190 20530 0 0 {name=x104}
C {devices/lab_pin.sym} -30 20440 0 0 {name=l453 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 20460 0 0 {name=l454 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 20620 2 0 {name=l455 lab=VDD}
C {devices/gnd.sym} 180 20620 0 0 {name=l456 lab=GND}
C {SRAM/PIM_NOR.sym} 190 20750 0 0 {name=x105}
C {devices/lab_pin.sym} -30 20660 0 0 {name=l457 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 20680 0 0 {name=l458 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 20840 2 0 {name=l459 lab=VDD}
C {devices/gnd.sym} 180 20840 0 0 {name=l460 lab=GND}
C {SRAM/PIM_NOR.sym} 190 20980 0 0 {name=x106}
C {devices/lab_pin.sym} -30 20890 0 0 {name=l461 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 20910 0 0 {name=l462 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 21070 2 0 {name=l463 lab=VDD}
C {devices/gnd.sym} 180 21070 0 0 {name=l464 lab=GND}
C {SRAM/PIM_NOR.sym} 190 21240 0 0 {name=x107}
C {devices/lab_pin.sym} -30 21150 0 0 {name=l465 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 21170 0 0 {name=l466 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 21330 2 0 {name=l467 lab=VDD}
C {devices/gnd.sym} 180 21330 0 0 {name=l468 lab=GND}
C {SRAM/PIM_NOR.sym} 190 21500 0 0 {name=x108}
C {devices/lab_pin.sym} -30 21410 0 0 {name=l469 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 21430 0 0 {name=l470 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 21590 2 0 {name=l471 lab=VDD}
C {devices/gnd.sym} 180 21590 0 0 {name=l472 lab=GND}
C {SRAM/PIM_NOR.sym} 190 21720 0 0 {name=x109}
C {devices/lab_pin.sym} -30 21630 0 0 {name=l473 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 21650 0 0 {name=l474 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 21810 2 0 {name=l475 lab=VDD}
C {devices/gnd.sym} 180 21810 0 0 {name=l476 lab=GND}
C {SRAM/PIM_NOR.sym} 190 21950 0 0 {name=x110}
C {devices/lab_pin.sym} -30 21860 0 0 {name=l477 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 21880 0 0 {name=l478 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 22010 2 0 {name=l479 lab=VDD}
C {devices/gnd.sym} 180 22040 0 0 {name=l480 lab=GND}
C {SRAM/PIM_NOR.sym} 190 22120 0 0 {name=x111}
C {devices/lab_pin.sym} -30 22030 0 0 {name=l481 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 22050 0 0 {name=l482 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 22210 2 0 {name=l483 lab=VDD}
C {devices/gnd.sym} 180 22210 0 0 {name=l484 lab=GND}
C {SRAM/PIM_NOR.sym} 190 22380 0 0 {name=x112}
C {devices/lab_pin.sym} -30 22290 0 0 {name=l485 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 22310 0 0 {name=l486 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 22470 2 0 {name=l487 lab=VDD}
C {devices/gnd.sym} 180 22470 0 0 {name=l488 lab=GND}
C {SRAM/PIM_NOR.sym} 190 22600 0 0 {name=x113}
C {devices/lab_pin.sym} -30 22510 0 0 {name=l489 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 22530 0 0 {name=l490 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 22690 2 0 {name=l491 lab=VDD}
C {devices/gnd.sym} 180 22690 0 0 {name=l492 lab=GND}
C {SRAM/PIM_NOR.sym} 190 22830 0 0 {name=x114}
C {devices/lab_pin.sym} -30 22740 0 0 {name=l493 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 22760 0 0 {name=l494 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 22920 2 0 {name=l495 lab=VDD}
C {devices/gnd.sym} 180 22920 0 0 {name=l496 lab=GND}
C {SRAM/PIM_NOR.sym} 190 23090 0 0 {name=x115}
C {devices/lab_pin.sym} -30 23000 0 0 {name=l497 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 23020 0 0 {name=l498 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 23180 2 0 {name=l499 lab=VDD}
C {devices/gnd.sym} 180 23180 0 0 {name=l500 lab=GND}
C {SRAM/PIM_NOR.sym} 190 23350 0 0 {name=x116}
C {devices/lab_pin.sym} -30 23260 0 0 {name=l501 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 23280 0 0 {name=l502 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 23440 2 0 {name=l503 lab=VDD}
C {devices/gnd.sym} 180 23440 0 0 {name=l504 lab=GND}
C {SRAM/PIM_NOR.sym} 190 23570 0 0 {name=x117}
C {devices/lab_pin.sym} -30 23480 0 0 {name=l505 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 23500 0 0 {name=l506 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 23660 2 0 {name=l507 lab=VDD}
C {devices/gnd.sym} 180 23660 0 0 {name=l508 lab=GND}
C {SRAM/PIM_NOR.sym} 190 23800 0 0 {name=x118}
C {devices/lab_pin.sym} -30 23710 0 0 {name=l509 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 23730 0 0 {name=l510 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 23890 2 0 {name=l511 lab=VDD}
C {devices/gnd.sym} 180 23890 0 0 {name=l512 lab=GND}
C {SRAM/PIM_NOR.sym} 190 24040 0 0 {name=x119}
C {devices/lab_pin.sym} -30 23950 0 0 {name=l513 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 23970 0 0 {name=l514 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 24130 2 0 {name=l515 lab=VDD}
C {devices/gnd.sym} 180 24130 0 0 {name=l516 lab=GND}
C {SRAM/PIM_NOR.sym} 190 24300 0 0 {name=x120}
C {devices/lab_pin.sym} -30 24210 0 0 {name=l517 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 24230 0 0 {name=l518 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 24390 2 0 {name=l519 lab=VDD}
C {devices/gnd.sym} 180 24390 0 0 {name=l520 lab=GND}
C {SRAM/PIM_NOR.sym} 190 24520 0 0 {name=x121}
C {devices/lab_pin.sym} -30 24430 0 0 {name=l521 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 24450 0 0 {name=l522 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 24610 2 0 {name=l523 lab=VDD}
C {devices/gnd.sym} 180 24610 0 0 {name=l524 lab=GND}
C {SRAM/PIM_NOR.sym} 190 24750 0 0 {name=x122}
C {devices/lab_pin.sym} -30 24660 0 0 {name=l525 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 24680 0 0 {name=l526 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 24840 2 0 {name=l527 lab=VDD}
C {devices/gnd.sym} 180 24840 0 0 {name=l528 lab=GND}
C {SRAM/PIM_NOR.sym} 190 25010 0 0 {name=x123}
C {devices/lab_pin.sym} -30 24920 0 0 {name=l529 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 24940 0 0 {name=l530 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 25100 2 0 {name=l531 lab=VDD}
C {devices/gnd.sym} 180 25100 0 0 {name=l532 lab=GND}
C {SRAM/PIM_NOR.sym} 190 25270 0 0 {name=x124}
C {devices/lab_pin.sym} -30 25180 0 0 {name=l533 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 25200 0 0 {name=l534 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 25360 2 0 {name=l535 lab=VDD}
C {devices/gnd.sym} 180 25360 0 0 {name=l536 lab=GND}
C {SRAM/PIM_NOR.sym} 190 25490 0 0 {name=x125}
C {devices/lab_pin.sym} -30 25400 0 0 {name=l537 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 25420 0 0 {name=l538 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 25580 2 0 {name=l539 lab=VDD}
C {devices/gnd.sym} 180 25580 0 0 {name=l540 lab=GND}
C {SRAM/PIM_NOR.sym} 190 25720 0 0 {name=x126}
C {devices/lab_pin.sym} -30 25630 0 0 {name=l541 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 25650 0 0 {name=l542 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 25780 2 0 {name=l543 lab=VDD}
C {devices/gnd.sym} 180 25810 0 0 {name=l544 lab=GND}
C {SRAM/PIM_NOR.sym} 190 25890 0 0 {name=x127}
C {devices/lab_pin.sym} -30 25800 0 0 {name=l545 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 25820 0 0 {name=l546 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 25980 2 0 {name=l547 lab=VDD}
C {devices/gnd.sym} 180 25980 0 0 {name=l548 lab=GND}
C {SRAM/PIM_NOR.sym} 190 26150 0 0 {name=x128}
C {devices/lab_pin.sym} -30 26060 0 0 {name=l549 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 26080 0 0 {name=l550 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 26240 2 0 {name=l551 lab=VDD}
C {devices/gnd.sym} 180 26240 0 0 {name=l552 lab=GND}
C {SRAM/PIM_NOR.sym} 190 26370 0 0 {name=x129}
C {devices/lab_pin.sym} -30 26280 0 0 {name=l553 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 26300 0 0 {name=l554 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 26460 2 0 {name=l555 lab=VDD}
C {devices/gnd.sym} 180 26460 0 0 {name=l556 lab=GND}
C {SRAM/PIM_NOR.sym} 190 26600 0 0 {name=x130}
C {devices/lab_pin.sym} -30 26510 0 0 {name=l557 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 26530 0 0 {name=l558 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 26690 2 0 {name=l559 lab=VDD}
C {devices/gnd.sym} 180 26690 0 0 {name=l560 lab=GND}
C {SRAM/PIM_NOR.sym} 190 26860 0 0 {name=x131}
C {devices/lab_pin.sym} -30 26770 0 0 {name=l561 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 26790 0 0 {name=l562 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 26950 2 0 {name=l563 lab=VDD}
C {devices/gnd.sym} 180 26950 0 0 {name=l564 lab=GND}
C {SRAM/PIM_NOR.sym} 190 27120 0 0 {name=x132}
C {devices/lab_pin.sym} -30 27030 0 0 {name=l565 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 27050 0 0 {name=l566 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 27210 2 0 {name=l567 lab=VDD}
C {devices/gnd.sym} 180 27210 0 0 {name=l568 lab=GND}
C {SRAM/PIM_NOR.sym} 190 27340 0 0 {name=x133}
C {devices/lab_pin.sym} -30 27250 0 0 {name=l569 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 27270 0 0 {name=l570 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 27430 2 0 {name=l571 lab=VDD}
C {devices/gnd.sym} 180 27430 0 0 {name=l572 lab=GND}
C {SRAM/PIM_NOR.sym} 190 27570 0 0 {name=x134}
C {devices/lab_pin.sym} -30 27480 0 0 {name=l573 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 27500 0 0 {name=l574 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 27660 2 0 {name=l575 lab=VDD}
C {devices/gnd.sym} 180 27660 0 0 {name=l576 lab=GND}
C {SRAM/PIM_NOR.sym} 190 27810 0 0 {name=x135}
C {devices/lab_pin.sym} -30 27720 0 0 {name=l577 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 27740 0 0 {name=l578 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 27900 2 0 {name=l579 lab=VDD}
C {devices/gnd.sym} 180 27900 0 0 {name=l580 lab=GND}
C {SRAM/PIM_NOR.sym} 190 28070 0 0 {name=x136}
C {devices/lab_pin.sym} -30 27980 0 0 {name=l581 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 28000 0 0 {name=l582 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 28160 2 0 {name=l583 lab=VDD}
C {devices/gnd.sym} 180 28160 0 0 {name=l584 lab=GND}
C {SRAM/PIM_NOR.sym} 190 28290 0 0 {name=x137}
C {devices/lab_pin.sym} -30 28200 0 0 {name=l585 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 28220 0 0 {name=l586 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 28380 2 0 {name=l587 lab=VDD}
C {devices/gnd.sym} 180 28380 0 0 {name=l588 lab=GND}
C {SRAM/PIM_NOR.sym} 190 28520 0 0 {name=x138}
C {devices/lab_pin.sym} -30 28430 0 0 {name=l589 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 28450 0 0 {name=l590 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 28610 2 0 {name=l591 lab=VDD}
C {devices/gnd.sym} 180 28610 0 0 {name=l592 lab=GND}
C {SRAM/PIM_NOR.sym} 190 28780 0 0 {name=x139}
C {devices/lab_pin.sym} -30 28690 0 0 {name=l593 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 28710 0 0 {name=l594 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 28870 2 0 {name=l595 lab=VDD}
C {devices/gnd.sym} 180 28870 0 0 {name=l596 lab=GND}
C {SRAM/PIM_NOR.sym} 190 29040 0 0 {name=x140}
C {devices/lab_pin.sym} -30 28950 0 0 {name=l597 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 28970 0 0 {name=l598 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 29130 2 0 {name=l599 lab=VDD}
C {devices/gnd.sym} 180 29130 0 0 {name=l600 lab=GND}
C {SRAM/PIM_NOR.sym} 190 29260 0 0 {name=x141}
C {devices/lab_pin.sym} -30 29170 0 0 {name=l601 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 29190 0 0 {name=l602 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 29350 2 0 {name=l603 lab=VDD}
C {devices/gnd.sym} 180 29350 0 0 {name=l604 lab=GND}
C {SRAM/PIM_NOR.sym} 190 29490 0 0 {name=x142}
C {devices/lab_pin.sym} -30 29400 0 0 {name=l605 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 29420 0 0 {name=l606 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 29550 2 0 {name=l607 lab=VDD}
C {devices/gnd.sym} 180 29580 0 0 {name=l608 lab=GND}
C {SRAM/PIM_NOR.sym} 190 29660 0 0 {name=x143}
C {devices/lab_pin.sym} -30 29570 0 0 {name=l609 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 29590 0 0 {name=l610 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 29750 2 0 {name=l611 lab=VDD}
C {devices/gnd.sym} 180 29750 0 0 {name=l612 lab=GND}
C {SRAM/PIM_NOR.sym} 190 29920 0 0 {name=x144}
C {devices/lab_pin.sym} -30 29830 0 0 {name=l613 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 29850 0 0 {name=l614 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 30010 2 0 {name=l615 lab=VDD}
C {devices/gnd.sym} 180 30010 0 0 {name=l616 lab=GND}
C {SRAM/PIM_NOR.sym} 190 30140 0 0 {name=x145}
C {devices/lab_pin.sym} -30 30050 0 0 {name=l617 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 30070 0 0 {name=l618 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 30230 2 0 {name=l619 lab=VDD}
C {devices/gnd.sym} 180 30230 0 0 {name=l620 lab=GND}
C {SRAM/PIM_NOR.sym} 190 30370 0 0 {name=x146}
C {devices/lab_pin.sym} -30 30280 0 0 {name=l621 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 30300 0 0 {name=l622 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 30460 2 0 {name=l623 lab=VDD}
C {devices/gnd.sym} 180 30460 0 0 {name=l624 lab=GND}
C {SRAM/PIM_NOR.sym} 190 30630 0 0 {name=x147}
C {devices/lab_pin.sym} -30 30540 0 0 {name=l625 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 30560 0 0 {name=l626 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 30720 2 0 {name=l627 lab=VDD}
C {devices/gnd.sym} 180 30720 0 0 {name=l628 lab=GND}
C {SRAM/PIM_NOR.sym} 190 30890 0 0 {name=x148}
C {devices/lab_pin.sym} -30 30800 0 0 {name=l629 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 30820 0 0 {name=l630 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 30980 2 0 {name=l631 lab=VDD}
C {devices/gnd.sym} 180 30980 0 0 {name=l632 lab=GND}
C {SRAM/PIM_NOR.sym} 190 31110 0 0 {name=x149}
C {devices/lab_pin.sym} -30 31020 0 0 {name=l633 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 31040 0 0 {name=l634 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 31200 2 0 {name=l635 lab=VDD}
C {devices/gnd.sym} 180 31200 0 0 {name=l636 lab=GND}
C {SRAM/PIM_NOR.sym} 190 31340 0 0 {name=x150}
C {devices/lab_pin.sym} -30 31250 0 0 {name=l637 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 31270 0 0 {name=l638 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 31430 2 0 {name=l639 lab=VDD}
C {devices/gnd.sym} 180 31430 0 0 {name=l640 lab=GND}
C {SRAM/PIM_NOR.sym} 190 31580 0 0 {name=x151}
C {devices/lab_pin.sym} -30 31490 0 0 {name=l641 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 31510 0 0 {name=l642 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 31670 2 0 {name=l643 lab=VDD}
C {devices/gnd.sym} 180 31670 0 0 {name=l644 lab=GND}
C {SRAM/PIM_NOR.sym} 190 31840 0 0 {name=x152}
C {devices/lab_pin.sym} -30 31750 0 0 {name=l645 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 31770 0 0 {name=l646 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 31930 2 0 {name=l647 lab=VDD}
C {devices/gnd.sym} 180 31930 0 0 {name=l648 lab=GND}
C {SRAM/PIM_NOR.sym} 190 32060 0 0 {name=x153}
C {devices/lab_pin.sym} -30 31970 0 0 {name=l649 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 31990 0 0 {name=l650 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 32150 2 0 {name=l651 lab=VDD}
C {devices/gnd.sym} 180 32150 0 0 {name=l652 lab=GND}
C {SRAM/PIM_NOR.sym} 190 32290 0 0 {name=x154}
C {devices/lab_pin.sym} -30 32200 0 0 {name=l653 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 32220 0 0 {name=l654 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 32380 2 0 {name=l655 lab=VDD}
C {devices/gnd.sym} 180 32380 0 0 {name=l656 lab=GND}
C {SRAM/PIM_NOR.sym} 190 32550 0 0 {name=x155}
C {devices/lab_pin.sym} -30 32460 0 0 {name=l657 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 32480 0 0 {name=l658 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 32640 2 0 {name=l659 lab=VDD}
C {devices/gnd.sym} 180 32640 0 0 {name=l660 lab=GND}
C {SRAM/PIM_NOR.sym} 190 32810 0 0 {name=x156}
C {devices/lab_pin.sym} -30 32720 0 0 {name=l661 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 32740 0 0 {name=l662 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 32900 2 0 {name=l663 lab=VDD}
C {devices/gnd.sym} 180 32900 0 0 {name=l664 lab=GND}
C {SRAM/PIM_NOR.sym} 190 33030 0 0 {name=x157}
C {devices/lab_pin.sym} -30 32940 0 0 {name=l665 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 32960 0 0 {name=l666 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 33120 2 0 {name=l667 lab=VDD}
C {devices/gnd.sym} 180 33120 0 0 {name=l668 lab=GND}
C {SRAM/PIM_NOR.sym} 190 33260 0 0 {name=x158}
C {devices/lab_pin.sym} -30 33170 0 0 {name=l669 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 33190 0 0 {name=l670 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 240 33320 2 0 {name=l671 lab=VDD}
C {devices/gnd.sym} 180 33350 0 0 {name=l672 lab=GND}
C {SRAM/PIM_NOR.sym} 190 33430 0 0 {name=x159}
C {devices/lab_pin.sym} -30 33340 0 0 {name=l673 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 33360 0 0 {name=l674 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 33520 2 0 {name=l675 lab=VDD}
C {devices/gnd.sym} 180 33520 0 0 {name=l676 lab=GND}
C {SRAM/PIM_NOR.sym} 190 33690 0 0 {name=x160}
C {devices/lab_pin.sym} -30 33600 0 0 {name=l677 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 33620 0 0 {name=l678 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 33780 2 0 {name=l679 lab=VDD}
C {devices/gnd.sym} 180 33780 0 0 {name=l680 lab=GND}
C {SRAM/PIM_NOR.sym} 190 33910 0 0 {name=x161}
C {devices/lab_pin.sym} -30 33820 0 0 {name=l681 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 33840 0 0 {name=l682 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 34000 2 0 {name=l683 lab=VDD}
C {devices/gnd.sym} 180 34000 0 0 {name=l684 lab=GND}
C {SRAM/PIM_NOR.sym} 190 34140 0 0 {name=x162}
C {devices/lab_pin.sym} -30 34050 0 0 {name=l685 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 34070 0 0 {name=l686 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 34230 2 0 {name=l687 lab=VDD}
C {devices/gnd.sym} 180 34230 0 0 {name=l688 lab=GND}
C {SRAM/PIM_NOR.sym} 190 34400 0 0 {name=x163}
C {devices/lab_pin.sym} -30 34310 0 0 {name=l689 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 34330 0 0 {name=l690 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 34490 2 0 {name=l691 lab=VDD}
C {devices/gnd.sym} 180 34490 0 0 {name=l692 lab=GND}
C {SRAM/PIM_NOR.sym} 190 34660 0 0 {name=x164}
C {devices/lab_pin.sym} -30 34570 0 0 {name=l693 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 34590 0 0 {name=l694 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 34750 2 0 {name=l695 lab=VDD}
C {devices/gnd.sym} 180 34750 0 0 {name=l696 lab=GND}
C {SRAM/PIM_NOR.sym} 190 34880 0 0 {name=x165}
C {devices/lab_pin.sym} -30 34790 0 0 {name=l697 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 34810 0 0 {name=l698 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 34970 2 0 {name=l699 lab=VDD}
C {devices/gnd.sym} 180 34970 0 0 {name=l700 lab=GND}
C {SRAM/PIM_NOR.sym} 190 35110 0 0 {name=x166}
C {devices/lab_pin.sym} -30 35020 0 0 {name=l701 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 35040 0 0 {name=l702 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 35200 2 0 {name=l703 lab=VDD}
C {devices/gnd.sym} 180 35200 0 0 {name=l704 lab=GND}
C {SRAM/PIM_NOR.sym} 190 35350 0 0 {name=x167}
C {devices/lab_pin.sym} -30 35260 0 0 {name=l705 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 35280 0 0 {name=l706 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 35440 2 0 {name=l707 lab=VDD}
C {devices/gnd.sym} 180 35440 0 0 {name=l708 lab=GND}
C {SRAM/PIM_NOR.sym} 190 35610 0 0 {name=x168}
C {devices/lab_pin.sym} -30 35520 0 0 {name=l709 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 35540 0 0 {name=l710 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 35700 2 0 {name=l711 lab=VDD}
C {devices/gnd.sym} 180 35700 0 0 {name=l712 lab=GND}
C {SRAM/PIM_NOR.sym} 190 35830 0 0 {name=x169}
C {devices/lab_pin.sym} -30 35740 0 0 {name=l713 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 35760 0 0 {name=l714 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 35920 2 0 {name=l715 lab=VDD}
C {devices/gnd.sym} 180 35920 0 0 {name=l716 lab=GND}
C {SRAM/PIM_NOR.sym} 190 36060 0 0 {name=x170}
C {devices/lab_pin.sym} -30 35970 0 0 {name=l717 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 35990 0 0 {name=l718 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 36150 2 0 {name=l719 lab=VDD}
C {devices/gnd.sym} 180 36150 0 0 {name=l720 lab=GND}
C {SRAM/PIM_NOR.sym} 190 36320 0 0 {name=x171}
C {devices/lab_pin.sym} -30 36230 0 0 {name=l721 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 36250 0 0 {name=l722 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 36410 2 0 {name=l723 lab=VDD}
C {devices/gnd.sym} 180 36410 0 0 {name=l724 lab=GND}
C {SRAM/PIM_NOR.sym} 190 36580 0 0 {name=x172}
C {devices/lab_pin.sym} -30 36490 0 0 {name=l725 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 36510 0 0 {name=l726 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 36670 2 0 {name=l727 lab=VDD}
C {devices/gnd.sym} 180 36670 0 0 {name=l728 lab=GND}
C {SRAM/PIM_NOR.sym} 190 36800 0 0 {name=x173}
C {devices/lab_pin.sym} -30 36710 0 0 {name=l729 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 36730 0 0 {name=l730 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 36890 2 0 {name=l731 lab=VDD}
C {devices/gnd.sym} 180 36890 0 0 {name=l732 lab=GND}
C {SRAM/PIM_NOR.sym} 190 37030 0 0 {name=x174}
C {devices/lab_pin.sym} -30 36940 0 0 {name=l733 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 36960 0 0 {name=l734 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 37090 2 0 {name=l735 lab=VDD}
C {devices/gnd.sym} 180 37120 0 0 {name=l736 lab=GND}
C {SRAM/PIM_NOR.sym} 190 37200 0 0 {name=x175}
C {devices/lab_pin.sym} -30 37110 0 0 {name=l737 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 37130 0 0 {name=l738 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 37290 2 0 {name=l739 lab=VDD}
C {devices/gnd.sym} 180 37290 0 0 {name=l740 lab=GND}
C {SRAM/PIM_NOR.sym} 190 37460 0 0 {name=x176}
C {devices/lab_pin.sym} -30 37370 0 0 {name=l741 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 37390 0 0 {name=l742 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 37550 2 0 {name=l743 lab=VDD}
C {devices/gnd.sym} 180 37550 0 0 {name=l744 lab=GND}
C {SRAM/PIM_NOR.sym} 190 37680 0 0 {name=x177}
C {devices/lab_pin.sym} -30 37590 0 0 {name=l745 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 37610 0 0 {name=l746 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 37770 2 0 {name=l747 lab=VDD}
C {devices/gnd.sym} 180 37770 0 0 {name=l748 lab=GND}
C {SRAM/PIM_NOR.sym} 190 37910 0 0 {name=x178}
C {devices/lab_pin.sym} -30 37820 0 0 {name=l749 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 37840 0 0 {name=l750 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 38000 2 0 {name=l751 lab=VDD}
C {devices/gnd.sym} 180 38000 0 0 {name=l752 lab=GND}
C {SRAM/PIM_NOR.sym} 190 38170 0 0 {name=x179}
C {devices/lab_pin.sym} -30 38080 0 0 {name=l753 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 38100 0 0 {name=l754 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 38260 2 0 {name=l755 lab=VDD}
C {devices/gnd.sym} 180 38260 0 0 {name=l756 lab=GND}
C {SRAM/PIM_NOR.sym} 190 38430 0 0 {name=x180}
C {devices/lab_pin.sym} -30 38340 0 0 {name=l757 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 38360 0 0 {name=l758 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 38520 2 0 {name=l759 lab=VDD}
C {devices/gnd.sym} 180 38520 0 0 {name=l760 lab=GND}
C {SRAM/PIM_NOR.sym} 190 38650 0 0 {name=x181}
C {devices/lab_pin.sym} -30 38560 0 0 {name=l761 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 38580 0 0 {name=l762 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 38740 2 0 {name=l763 lab=VDD}
C {devices/gnd.sym} 180 38740 0 0 {name=l764 lab=GND}
C {SRAM/PIM_NOR.sym} 190 38880 0 0 {name=x182}
C {devices/lab_pin.sym} -30 38790 0 0 {name=l765 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 38810 0 0 {name=l766 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 38970 2 0 {name=l767 lab=VDD}
C {devices/gnd.sym} 180 38970 0 0 {name=l768 lab=GND}
C {SRAM/PIM_NOR.sym} 190 39120 0 0 {name=x183}
C {devices/lab_pin.sym} -30 39030 0 0 {name=l769 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 39050 0 0 {name=l770 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 39210 2 0 {name=l771 lab=VDD}
C {devices/gnd.sym} 180 39210 0 0 {name=l772 lab=GND}
C {SRAM/PIM_NOR.sym} 190 39380 0 0 {name=x184}
C {devices/lab_pin.sym} -30 39290 0 0 {name=l773 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 39310 0 0 {name=l774 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 39470 2 0 {name=l775 lab=VDD}
C {devices/gnd.sym} 180 39470 0 0 {name=l776 lab=GND}
C {SRAM/PIM_NOR.sym} 190 39600 0 0 {name=x185}
C {devices/lab_pin.sym} -30 39510 0 0 {name=l777 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 39530 0 0 {name=l778 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 39690 2 0 {name=l779 lab=VDD}
C {devices/gnd.sym} 180 39690 0 0 {name=l780 lab=GND}
C {SRAM/PIM_NOR.sym} 190 39830 0 0 {name=x186}
C {devices/lab_pin.sym} -30 39740 0 0 {name=l781 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 39760 0 0 {name=l782 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 39920 2 0 {name=l783 lab=VDD}
C {devices/gnd.sym} 180 39920 0 0 {name=l784 lab=GND}
C {SRAM/PIM_NOR.sym} 190 40090 0 0 {name=x187}
C {devices/lab_pin.sym} -30 40000 0 0 {name=l785 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 40020 0 0 {name=l786 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 40180 2 0 {name=l787 lab=VDD}
C {devices/gnd.sym} 180 40180 0 0 {name=l788 lab=GND}
C {SRAM/PIM_NOR.sym} 190 40350 0 0 {name=x188}
C {devices/lab_pin.sym} -30 40260 0 0 {name=l789 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 40280 0 0 {name=l790 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 40440 2 0 {name=l791 lab=VDD}
C {devices/gnd.sym} 180 40440 0 0 {name=l792 lab=GND}
C {SRAM/PIM_NOR.sym} 190 40570 0 0 {name=x189}
C {devices/lab_pin.sym} -30 40480 0 0 {name=l793 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 40500 0 0 {name=l794 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 40660 2 0 {name=l795 lab=VDD}
C {devices/gnd.sym} 180 40660 0 0 {name=l796 lab=GND}
C {SRAM/PIM_NOR.sym} 190 40800 0 0 {name=x190}
C {devices/lab_pin.sym} -30 40710 0 0 {name=l797 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 40730 0 0 {name=l798 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 40860 2 0 {name=l799 lab=VDD}
C {devices/gnd.sym} 180 40890 0 0 {name=l800 lab=GND}
C {SRAM/PIM_NOR.sym} 190 40970 0 0 {name=x191}
C {devices/lab_pin.sym} -30 40880 0 0 {name=l801 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 40900 0 0 {name=l802 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 41060 2 0 {name=l803 lab=VDD}
C {devices/gnd.sym} 180 41060 0 0 {name=l804 lab=GND}
C {SRAM/PIM_NOR.sym} 190 41230 0 0 {name=x192}
C {devices/lab_pin.sym} -30 41140 0 0 {name=l805 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 41160 0 0 {name=l806 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 41320 2 0 {name=l807 lab=VDD}
C {devices/gnd.sym} 180 41320 0 0 {name=l808 lab=GND}
C {SRAM/PIM_NOR.sym} 190 41450 0 0 {name=x193}
C {devices/lab_pin.sym} -30 41360 0 0 {name=l809 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 41380 0 0 {name=l810 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 41540 2 0 {name=l811 lab=VDD}
C {devices/gnd.sym} 180 41540 0 0 {name=l812 lab=GND}
C {SRAM/PIM_NOR.sym} 190 41680 0 0 {name=x194}
C {devices/lab_pin.sym} -30 41590 0 0 {name=l813 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 41610 0 0 {name=l814 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 41770 2 0 {name=l815 lab=VDD}
C {devices/gnd.sym} 180 41770 0 0 {name=l816 lab=GND}
C {SRAM/PIM_NOR.sym} 190 41940 0 0 {name=x195}
C {devices/lab_pin.sym} -30 41850 0 0 {name=l817 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 41870 0 0 {name=l818 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 42030 2 0 {name=l819 lab=VDD}
C {devices/gnd.sym} 180 42030 0 0 {name=l820 lab=GND}
C {SRAM/PIM_NOR.sym} 190 42200 0 0 {name=x196}
C {devices/lab_pin.sym} -30 42110 0 0 {name=l821 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 42130 0 0 {name=l822 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 42290 2 0 {name=l823 lab=VDD}
C {devices/gnd.sym} 180 42290 0 0 {name=l824 lab=GND}
C {SRAM/PIM_NOR.sym} 190 42420 0 0 {name=x197}
C {devices/lab_pin.sym} -30 42330 0 0 {name=l825 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 42350 0 0 {name=l826 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 42510 2 0 {name=l827 lab=VDD}
C {devices/gnd.sym} 180 42510 0 0 {name=l828 lab=GND}
C {SRAM/PIM_NOR.sym} 190 42650 0 0 {name=x198}
C {devices/lab_pin.sym} -30 42560 0 0 {name=l829 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 42580 0 0 {name=l830 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 42740 2 0 {name=l831 lab=VDD}
C {devices/gnd.sym} 180 42740 0 0 {name=l832 lab=GND}
C {SRAM/PIM_NOR.sym} 190 42890 0 0 {name=x199}
C {devices/lab_pin.sym} -30 42800 0 0 {name=l833 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 42820 0 0 {name=l834 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 42980 2 0 {name=l835 lab=VDD}
C {devices/gnd.sym} 180 42980 0 0 {name=l836 lab=GND}
C {SRAM/PIM_NOR.sym} 190 43150 0 0 {name=x200}
C {devices/lab_pin.sym} -30 43060 0 0 {name=l837 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 43080 0 0 {name=l838 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 43240 2 0 {name=l839 lab=VDD}
C {devices/gnd.sym} 180 43240 0 0 {name=l840 lab=GND}
C {SRAM/PIM_NOR.sym} 190 43370 0 0 {name=x201}
C {devices/lab_pin.sym} -30 43280 0 0 {name=l841 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 43300 0 0 {name=l842 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 43460 2 0 {name=l843 lab=VDD}
C {devices/gnd.sym} 180 43460 0 0 {name=l844 lab=GND}
C {SRAM/PIM_NOR.sym} 190 43600 0 0 {name=x202}
C {devices/lab_pin.sym} -30 43510 0 0 {name=l845 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 43530 0 0 {name=l846 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 43690 2 0 {name=l847 lab=VDD}
C {devices/gnd.sym} 180 43690 0 0 {name=l848 lab=GND}
C {SRAM/PIM_NOR.sym} 190 43860 0 0 {name=x203}
C {devices/lab_pin.sym} -30 43770 0 0 {name=l849 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 43790 0 0 {name=l850 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 43950 2 0 {name=l851 lab=VDD}
C {devices/gnd.sym} 180 43950 0 0 {name=l852 lab=GND}
C {SRAM/PIM_NOR.sym} 190 44120 0 0 {name=x204}
C {devices/lab_pin.sym} -30 44030 0 0 {name=l853 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 44050 0 0 {name=l854 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 44210 2 0 {name=l855 lab=VDD}
C {devices/gnd.sym} 180 44210 0 0 {name=l856 lab=GND}
C {SRAM/PIM_NOR.sym} 190 44340 0 0 {name=x205}
C {devices/lab_pin.sym} -30 44250 0 0 {name=l857 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 44270 0 0 {name=l858 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 44430 2 0 {name=l859 lab=VDD}
C {devices/gnd.sym} 180 44430 0 0 {name=l860 lab=GND}
C {SRAM/PIM_NOR.sym} 190 44570 0 0 {name=x206}
C {devices/lab_pin.sym} -30 44480 0 0 {name=l861 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 44500 0 0 {name=l862 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 240 44630 2 0 {name=l863 lab=VDD}
C {devices/gnd.sym} 180 44660 0 0 {name=l864 lab=GND}
C {SRAM/PIM_NOR.sym} 190 44740 0 0 {name=x207}
C {devices/lab_pin.sym} -30 44650 0 0 {name=l865 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 44670 0 0 {name=l866 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 44830 2 0 {name=l867 lab=VDD}
C {devices/gnd.sym} 180 44830 0 0 {name=l868 lab=GND}
C {SRAM/PIM_NOR.sym} 190 45000 0 0 {name=x208}
C {devices/lab_pin.sym} -30 44910 0 0 {name=l869 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 44930 0 0 {name=l870 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 45090 2 0 {name=l871 lab=VDD}
C {devices/gnd.sym} 180 45090 0 0 {name=l872 lab=GND}
C {SRAM/PIM_NOR.sym} 190 45220 0 0 {name=x209}
C {devices/lab_pin.sym} -30 45130 0 0 {name=l873 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 45150 0 0 {name=l874 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 45310 2 0 {name=l875 lab=VDD}
C {devices/gnd.sym} 180 45310 0 0 {name=l876 lab=GND}
C {SRAM/PIM_NOR.sym} 190 45450 0 0 {name=x210}
C {devices/lab_pin.sym} -30 45360 0 0 {name=l877 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 45380 0 0 {name=l878 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 45540 2 0 {name=l879 lab=VDD}
C {devices/gnd.sym} 180 45540 0 0 {name=l880 lab=GND}
C {SRAM/PIM_NOR.sym} 190 45710 0 0 {name=x211}
C {devices/lab_pin.sym} -30 45620 0 0 {name=l881 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 45640 0 0 {name=l882 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 45800 2 0 {name=l883 lab=VDD}
C {devices/gnd.sym} 180 45800 0 0 {name=l884 lab=GND}
C {SRAM/PIM_NOR.sym} 190 45970 0 0 {name=x212}
C {devices/lab_pin.sym} -30 45880 0 0 {name=l885 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 45900 0 0 {name=l886 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 46060 2 0 {name=l887 lab=VDD}
C {devices/gnd.sym} 180 46060 0 0 {name=l888 lab=GND}
C {SRAM/PIM_NOR.sym} 190 46190 0 0 {name=x213}
C {devices/lab_pin.sym} -30 46100 0 0 {name=l889 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 46120 0 0 {name=l890 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 46280 2 0 {name=l891 lab=VDD}
C {devices/gnd.sym} 180 46280 0 0 {name=l892 lab=GND}
C {SRAM/PIM_NOR.sym} 190 46420 0 0 {name=x214}
C {devices/lab_pin.sym} -30 46330 0 0 {name=l893 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 46350 0 0 {name=l894 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 46510 2 0 {name=l895 lab=VDD}
C {devices/gnd.sym} 180 46510 0 0 {name=l896 lab=GND}
C {SRAM/PIM_NOR.sym} 190 46660 0 0 {name=x215}
C {devices/lab_pin.sym} -30 46570 0 0 {name=l897 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 46590 0 0 {name=l898 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 46750 2 0 {name=l899 lab=VDD}
C {devices/gnd.sym} 180 46750 0 0 {name=l900 lab=GND}
C {SRAM/PIM_NOR.sym} 190 46920 0 0 {name=x216}
C {devices/lab_pin.sym} -30 46830 0 0 {name=l901 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 46850 0 0 {name=l902 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 47010 2 0 {name=l903 lab=VDD}
C {devices/gnd.sym} 180 47010 0 0 {name=l904 lab=GND}
C {SRAM/PIM_NOR.sym} 190 47140 0 0 {name=x217}
C {devices/lab_pin.sym} -30 47050 0 0 {name=l905 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 47070 0 0 {name=l906 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 47230 2 0 {name=l907 lab=VDD}
C {devices/gnd.sym} 180 47230 0 0 {name=l908 lab=GND}
C {SRAM/PIM_NOR.sym} 190 47370 0 0 {name=x218}
C {devices/lab_pin.sym} -30 47280 0 0 {name=l909 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 47300 0 0 {name=l910 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 47460 2 0 {name=l911 lab=VDD}
C {devices/gnd.sym} 180 47460 0 0 {name=l912 lab=GND}
C {SRAM/PIM_NOR.sym} 190 47630 0 0 {name=x219}
C {devices/lab_pin.sym} -30 47540 0 0 {name=l913 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 47560 0 0 {name=l914 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 47720 2 0 {name=l915 lab=VDD}
C {devices/gnd.sym} 180 47720 0 0 {name=l916 lab=GND}
C {SRAM/PIM_NOR.sym} 190 47890 0 0 {name=x220}
C {devices/lab_pin.sym} -30 47800 0 0 {name=l917 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 47820 0 0 {name=l918 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 47980 2 0 {name=l919 lab=VDD}
C {devices/gnd.sym} 180 47980 0 0 {name=l920 lab=GND}
C {SRAM/PIM_NOR.sym} 190 48110 0 0 {name=x221}
C {devices/lab_pin.sym} -30 48020 0 0 {name=l921 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 48040 0 0 {name=l922 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 48200 2 0 {name=l923 lab=VDD}
C {devices/gnd.sym} 180 48200 0 0 {name=l924 lab=GND}
C {SRAM/PIM_NOR.sym} 190 48340 0 0 {name=x222}
C {devices/lab_pin.sym} -30 48250 0 0 {name=l925 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 48270 0 0 {name=l926 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 48400 2 0 {name=l927 lab=VDD}
C {devices/gnd.sym} 180 48430 0 0 {name=l928 lab=GND}
C {SRAM/PIM_NOR.sym} 190 48510 0 0 {name=x223}
C {devices/lab_pin.sym} -30 48420 0 0 {name=l929 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 48440 0 0 {name=l930 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 48600 2 0 {name=l931 lab=VDD}
C {devices/gnd.sym} 180 48600 0 0 {name=l932 lab=GND}
C {SRAM/PIM_NOR.sym} 190 48770 0 0 {name=x224}
C {devices/lab_pin.sym} -30 48680 0 0 {name=l933 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 48700 0 0 {name=l934 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 48860 2 0 {name=l935 lab=VDD}
C {devices/gnd.sym} 180 48860 0 0 {name=l936 lab=GND}
C {SRAM/PIM_NOR.sym} 190 48990 0 0 {name=x225}
C {devices/lab_pin.sym} -30 48900 0 0 {name=l937 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 48920 0 0 {name=l938 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 49080 2 0 {name=l939 lab=VDD}
C {devices/gnd.sym} 180 49080 0 0 {name=l940 lab=GND}
C {SRAM/PIM_NOR.sym} 190 49220 0 0 {name=x226}
C {devices/lab_pin.sym} -30 49130 0 0 {name=l941 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 49150 0 0 {name=l942 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 49310 2 0 {name=l943 lab=VDD}
C {devices/gnd.sym} 180 49310 0 0 {name=l944 lab=GND}
C {SRAM/PIM_NOR.sym} 190 49480 0 0 {name=x227}
C {devices/lab_pin.sym} -30 49390 0 0 {name=l945 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 49410 0 0 {name=l946 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 49570 2 0 {name=l947 lab=VDD}
C {devices/gnd.sym} 180 49570 0 0 {name=l948 lab=GND}
C {SRAM/PIM_NOR.sym} 190 49740 0 0 {name=x228}
C {devices/lab_pin.sym} -30 49650 0 0 {name=l949 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 49670 0 0 {name=l950 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 49830 2 0 {name=l951 lab=VDD}
C {devices/gnd.sym} 180 49830 0 0 {name=l952 lab=GND}
C {SRAM/PIM_NOR.sym} 190 49960 0 0 {name=x229}
C {devices/lab_pin.sym} -30 49870 0 0 {name=l953 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 49890 0 0 {name=l954 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 50050 2 0 {name=l955 lab=VDD}
C {devices/gnd.sym} 180 50050 0 0 {name=l956 lab=GND}
C {SRAM/PIM_NOR.sym} 190 50190 0 0 {name=x230}
C {devices/lab_pin.sym} -30 50100 0 0 {name=l957 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 50120 0 0 {name=l958 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 50280 2 0 {name=l959 lab=VDD}
C {devices/gnd.sym} 180 50280 0 0 {name=l960 lab=GND}
C {SRAM/PIM_NOR.sym} 190 50430 0 0 {name=x231}
C {devices/lab_pin.sym} -30 50340 0 0 {name=l961 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 50360 0 0 {name=l962 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 50520 2 0 {name=l963 lab=VDD}
C {devices/gnd.sym} 180 50520 0 0 {name=l964 lab=GND}
C {SRAM/PIM_NOR.sym} 190 50690 0 0 {name=x232}
C {devices/lab_pin.sym} -30 50600 0 0 {name=l965 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 50620 0 0 {name=l966 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 50780 2 0 {name=l967 lab=VDD}
C {devices/gnd.sym} 180 50780 0 0 {name=l968 lab=GND}
C {SRAM/PIM_NOR.sym} 190 50910 0 0 {name=x233}
C {devices/lab_pin.sym} -30 50820 0 0 {name=l969 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 50840 0 0 {name=l970 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 51000 2 0 {name=l971 lab=VDD}
C {devices/gnd.sym} 180 51000 0 0 {name=l972 lab=GND}
C {SRAM/PIM_NOR.sym} 190 51140 0 0 {name=x234}
C {devices/lab_pin.sym} -30 51050 0 0 {name=l973 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 51070 0 0 {name=l974 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 51230 2 0 {name=l975 lab=VDD}
C {devices/gnd.sym} 180 51230 0 0 {name=l976 lab=GND}
C {SRAM/PIM_NOR.sym} 190 51400 0 0 {name=x235}
C {devices/lab_pin.sym} -30 51310 0 0 {name=l977 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 51330 0 0 {name=l978 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 51490 2 0 {name=l979 lab=VDD}
C {devices/gnd.sym} 180 51490 0 0 {name=l980 lab=GND}
C {SRAM/PIM_NOR.sym} 190 51660 0 0 {name=x236}
C {devices/lab_pin.sym} -30 51570 0 0 {name=l981 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 51590 0 0 {name=l982 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 51750 2 0 {name=l983 lab=VDD}
C {devices/gnd.sym} 180 51750 0 0 {name=l984 lab=GND}
C {SRAM/PIM_NOR.sym} 190 51880 0 0 {name=x237}
C {devices/lab_pin.sym} -30 51790 0 0 {name=l985 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 51810 0 0 {name=l986 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 51970 2 0 {name=l987 lab=VDD}
C {devices/gnd.sym} 180 51970 0 0 {name=l988 lab=GND}
C {SRAM/PIM_NOR.sym} 190 52110 0 0 {name=x238}
C {devices/lab_pin.sym} -30 52020 0 0 {name=l989 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 52040 0 0 {name=l990 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 240 52170 2 0 {name=l991 lab=VDD}
C {devices/gnd.sym} 180 52200 0 0 {name=l992 lab=GND}
C {SRAM/PIM_NOR.sym} 190 52280 0 0 {name=x239}
C {devices/lab_pin.sym} -30 52190 0 0 {name=l993 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 52210 0 0 {name=l994 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 52370 2 0 {name=l995 lab=VDD}
C {devices/gnd.sym} 180 52370 0 0 {name=l996 lab=GND}
C {SRAM/PIM_NOR.sym} 190 52540 0 0 {name=x240}
C {devices/lab_pin.sym} -30 52450 0 0 {name=l997 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 52470 0 0 {name=l998 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 52630 2 0 {name=l999 lab=VDD}
C {devices/gnd.sym} 180 52630 0 0 {name=l1000 lab=GND}
C {SRAM/PIM_NOR.sym} 190 52760 0 0 {name=x241}
C {devices/lab_pin.sym} -30 52670 0 0 {name=l1001 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 52690 0 0 {name=l1002 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 52850 2 0 {name=l1003 lab=VDD}
C {devices/gnd.sym} 180 52850 0 0 {name=l1004 lab=GND}
C {SRAM/PIM_NOR.sym} 190 52990 0 0 {name=x242}
C {devices/lab_pin.sym} -30 52900 0 0 {name=l1005 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 52920 0 0 {name=l1006 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 53080 2 0 {name=l1007 lab=VDD}
C {devices/gnd.sym} 180 53080 0 0 {name=l1008 lab=GND}
C {SRAM/PIM_NOR.sym} 190 53250 0 0 {name=x243}
C {devices/lab_pin.sym} -30 53160 0 0 {name=l1009 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 53180 0 0 {name=l1010 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 53340 2 0 {name=l1011 lab=VDD}
C {devices/gnd.sym} 180 53340 0 0 {name=l1012 lab=GND}
C {SRAM/PIM_NOR.sym} 190 53510 0 0 {name=x244}
C {devices/lab_pin.sym} -30 53420 0 0 {name=l1013 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 53440 0 0 {name=l1014 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 53600 2 0 {name=l1015 lab=VDD}
C {devices/gnd.sym} 180 53600 0 0 {name=l1016 lab=GND}
C {SRAM/PIM_NOR.sym} 190 53730 0 0 {name=x245}
C {devices/lab_pin.sym} -30 53640 0 0 {name=l1017 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 53660 0 0 {name=l1018 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 53820 2 0 {name=l1019 lab=VDD}
C {devices/gnd.sym} 180 53820 0 0 {name=l1020 lab=GND}
C {SRAM/PIM_NOR.sym} 190 53960 0 0 {name=x246}
C {devices/lab_pin.sym} -30 53870 0 0 {name=l1021 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 53890 0 0 {name=l1022 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 54050 2 0 {name=l1023 lab=VDD}
C {devices/gnd.sym} 180 54050 0 0 {name=l1024 lab=GND}
C {SRAM/PIM_NOR.sym} 190 54200 0 0 {name=x247}
C {devices/lab_pin.sym} -30 54110 0 0 {name=l1025 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 54130 0 0 {name=l1026 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 54290 2 0 {name=l1027 lab=VDD}
C {devices/gnd.sym} 180 54290 0 0 {name=l1028 lab=GND}
C {SRAM/PIM_NOR.sym} 190 54460 0 0 {name=x248}
C {devices/lab_pin.sym} -30 54370 0 0 {name=l1029 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 54390 0 0 {name=l1030 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 54550 2 0 {name=l1031 lab=VDD}
C {devices/gnd.sym} 180 54550 0 0 {name=l1032 lab=GND}
C {SRAM/PIM_NOR.sym} 190 54680 0 0 {name=x249}
C {devices/lab_pin.sym} -30 54590 0 0 {name=l1033 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 54610 0 0 {name=l1034 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 54770 2 0 {name=l1035 lab=VDD}
C {devices/gnd.sym} 180 54770 0 0 {name=l1036 lab=GND}
C {SRAM/PIM_NOR.sym} 190 54910 0 0 {name=x250}
C {devices/lab_pin.sym} -30 54820 0 0 {name=l1037 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 54840 0 0 {name=l1038 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 55000 2 0 {name=l1039 lab=VDD}
C {devices/gnd.sym} 180 55000 0 0 {name=l1040 lab=GND}
C {SRAM/PIM_NOR.sym} 190 55170 0 0 {name=x251}
C {devices/lab_pin.sym} -30 55080 0 0 {name=l1041 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 55100 0 0 {name=l1042 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 55260 2 0 {name=l1043 lab=VDD}
C {devices/gnd.sym} 180 55260 0 0 {name=l1044 lab=GND}
C {SRAM/PIM_NOR.sym} 190 55430 0 0 {name=x252}
C {devices/lab_pin.sym} -30 55340 0 0 {name=l1045 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 55360 0 0 {name=l1046 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 55520 2 0 {name=l1047 lab=VDD}
C {devices/gnd.sym} 180 55520 0 0 {name=l1048 lab=GND}
C {SRAM/PIM_NOR.sym} 190 55650 0 0 {name=x253}
C {devices/lab_pin.sym} -30 55560 0 0 {name=l1049 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 55580 0 0 {name=l1050 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 55740 2 0 {name=l1051 lab=VDD}
C {devices/gnd.sym} 180 55740 0 0 {name=l1052 lab=GND}
C {SRAM/PIM_NOR.sym} 190 55880 0 0 {name=x254}
C {devices/lab_pin.sym} -30 55790 0 0 {name=l1053 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 55810 0 0 {name=l1054 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 55940 2 0 {name=l1055 lab=VDD}
C {devices/gnd.sym} 180 55970 0 0 {name=l1056 lab=GND}
C {SRAM/PIM_NOR.sym} 190 56050 0 0 {name=x255}
C {devices/lab_pin.sym} -30 55960 0 0 {name=l1057 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 55980 0 0 {name=l1058 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 56140 2 0 {name=l1059 lab=VDD}
C {devices/gnd.sym} 180 56140 0 0 {name=l1060 lab=GND}
C {SRAM/PIM_NOR.sym} 190 56310 0 0 {name=x256}
C {devices/lab_pin.sym} -30 56220 0 0 {name=l1061 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 56240 0 0 {name=l1062 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 56400 2 0 {name=l1063 lab=VDD}
C {devices/gnd.sym} 180 56400 0 0 {name=l1064 lab=GND}
C {SRAM/PIM_NOR.sym} 190 56530 0 0 {name=x257}
C {devices/lab_pin.sym} -30 56440 0 0 {name=l1065 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 56460 0 0 {name=l1066 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 56620 2 0 {name=l1067 lab=VDD}
C {devices/gnd.sym} 180 56620 0 0 {name=l1068 lab=GND}
C {SRAM/PIM_NOR.sym} 190 56760 0 0 {name=x258}
C {devices/lab_pin.sym} -30 56670 0 0 {name=l1069 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 56690 0 0 {name=l1070 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 56850 2 0 {name=l1071 lab=VDD}
C {devices/gnd.sym} 180 56850 0 0 {name=l1072 lab=GND}
C {SRAM/PIM_NOR.sym} 190 57020 0 0 {name=x259}
C {devices/lab_pin.sym} -30 56930 0 0 {name=l1073 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 56950 0 0 {name=l1074 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 57110 2 0 {name=l1075 lab=VDD}
C {devices/gnd.sym} 180 57110 0 0 {name=l1076 lab=GND}
C {SRAM/PIM_NOR.sym} 190 57280 0 0 {name=x260}
C {devices/lab_pin.sym} -30 57190 0 0 {name=l1077 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 57210 0 0 {name=l1078 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 57370 2 0 {name=l1079 lab=VDD}
C {devices/gnd.sym} 180 57370 0 0 {name=l1080 lab=GND}
C {SRAM/PIM_NOR.sym} 190 57500 0 0 {name=x261}
C {devices/lab_pin.sym} -30 57410 0 0 {name=l1081 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 57430 0 0 {name=l1082 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 57590 2 0 {name=l1083 lab=VDD}
C {devices/gnd.sym} 180 57590 0 0 {name=l1084 lab=GND}
C {SRAM/PIM_NOR.sym} 190 57730 0 0 {name=x262}
C {devices/lab_pin.sym} -30 57640 0 0 {name=l1085 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 57660 0 0 {name=l1086 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 57820 2 0 {name=l1087 lab=VDD}
C {devices/gnd.sym} 180 57820 0 0 {name=l1088 lab=GND}
C {SRAM/PIM_NOR.sym} 190 57970 0 0 {name=x263}
C {devices/lab_pin.sym} -30 57880 0 0 {name=l1089 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 57900 0 0 {name=l1090 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 58060 2 0 {name=l1091 lab=VDD}
C {devices/gnd.sym} 180 58060 0 0 {name=l1092 lab=GND}
C {SRAM/PIM_NOR.sym} 190 58230 0 0 {name=x264}
C {devices/lab_pin.sym} -30 58140 0 0 {name=l1093 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 58160 0 0 {name=l1094 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 58320 2 0 {name=l1095 lab=VDD}
C {devices/gnd.sym} 180 58320 0 0 {name=l1096 lab=GND}
C {SRAM/PIM_NOR.sym} 190 58450 0 0 {name=x265}
C {devices/lab_pin.sym} -30 58360 0 0 {name=l1097 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 58380 0 0 {name=l1098 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 58540 2 0 {name=l1099 lab=VDD}
C {devices/gnd.sym} 180 58540 0 0 {name=l1100 lab=GND}
C {SRAM/PIM_NOR.sym} 190 58680 0 0 {name=x266}
C {devices/lab_pin.sym} -30 58590 0 0 {name=l1101 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 58610 0 0 {name=l1102 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 58770 2 0 {name=l1103 lab=VDD}
C {devices/gnd.sym} 180 58770 0 0 {name=l1104 lab=GND}
C {SRAM/PIM_NOR.sym} 190 58940 0 0 {name=x267}
C {devices/lab_pin.sym} -30 58850 0 0 {name=l1105 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 58870 0 0 {name=l1106 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 59030 2 0 {name=l1107 lab=VDD}
C {devices/gnd.sym} 180 59030 0 0 {name=l1108 lab=GND}
C {SRAM/PIM_NOR.sym} 190 59200 0 0 {name=x268}
C {devices/lab_pin.sym} -30 59110 0 0 {name=l1109 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 59130 0 0 {name=l1110 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 59290 2 0 {name=l1111 lab=VDD}
C {devices/gnd.sym} 180 59290 0 0 {name=l1112 lab=GND}
C {SRAM/PIM_NOR.sym} 190 59420 0 0 {name=x269}
C {devices/lab_pin.sym} -30 59330 0 0 {name=l1113 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 59350 0 0 {name=l1114 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 59510 2 0 {name=l1115 lab=VDD}
C {devices/gnd.sym} 180 59510 0 0 {name=l1116 lab=GND}
C {SRAM/PIM_NOR.sym} 190 59650 0 0 {name=x270}
C {devices/lab_pin.sym} -30 59560 0 0 {name=l1117 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 59580 0 0 {name=l1118 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 250 59710 2 0 {name=l1119 lab=VDD}
C {devices/gnd.sym} 180 59740 0 0 {name=l1120 lab=GND}
C {SRAM/PIM_NOR.sym} 190 59820 0 0 {name=x271}
C {devices/lab_pin.sym} -30 59730 0 0 {name=l1121 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 59750 0 0 {name=l1122 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 59910 2 0 {name=l1123 lab=VDD}
C {devices/gnd.sym} 180 59910 0 0 {name=l1124 lab=GND}
C {SRAM/PIM_NOR.sym} 190 60080 0 0 {name=x272}
C {devices/lab_pin.sym} -30 59990 0 0 {name=l1125 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 60010 0 0 {name=l1126 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 60170 2 0 {name=l1127 lab=VDD}
C {devices/gnd.sym} 180 60170 0 0 {name=l1128 lab=GND}
C {SRAM/PIM_NOR.sym} 190 60300 0 0 {name=x273}
C {devices/lab_pin.sym} -30 60210 0 0 {name=l1129 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 60230 0 0 {name=l1130 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 60390 2 0 {name=l1131 lab=VDD}
C {devices/gnd.sym} 180 60390 0 0 {name=l1132 lab=GND}
C {SRAM/PIM_NOR.sym} 190 60530 0 0 {name=x274}
C {devices/lab_pin.sym} -30 60440 0 0 {name=l1133 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 60460 0 0 {name=l1134 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 60620 2 0 {name=l1135 lab=VDD}
C {devices/gnd.sym} 180 60620 0 0 {name=l1136 lab=GND}
C {SRAM/PIM_NOR.sym} 190 60790 0 0 {name=x275}
C {devices/lab_pin.sym} -30 60700 0 0 {name=l1137 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 60720 0 0 {name=l1138 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 60880 2 0 {name=l1139 lab=VDD}
C {devices/gnd.sym} 180 60880 0 0 {name=l1140 lab=GND}
C {SRAM/PIM_NOR.sym} 190 61050 0 0 {name=x276}
C {devices/lab_pin.sym} -30 60960 0 0 {name=l1141 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 60980 0 0 {name=l1142 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 61140 2 0 {name=l1143 lab=VDD}
C {devices/gnd.sym} 180 61140 0 0 {name=l1144 lab=GND}
C {SRAM/PIM_NOR.sym} 190 61270 0 0 {name=x277}
C {devices/lab_pin.sym} -30 61180 0 0 {name=l1145 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 61200 0 0 {name=l1146 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 61360 2 0 {name=l1147 lab=VDD}
C {devices/gnd.sym} 180 61360 0 0 {name=l1148 lab=GND}
C {SRAM/PIM_NOR.sym} 190 61500 0 0 {name=x278}
C {devices/lab_pin.sym} -30 61410 0 0 {name=l1149 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 61430 0 0 {name=l1150 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 61590 2 0 {name=l1151 lab=VDD}
C {devices/gnd.sym} 180 61590 0 0 {name=l1152 lab=GND}
C {SRAM/PIM_NOR.sym} 190 61740 0 0 {name=x279}
C {devices/lab_pin.sym} -30 61650 0 0 {name=l1153 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 61670 0 0 {name=l1154 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 61830 2 0 {name=l1155 lab=VDD}
C {devices/gnd.sym} 180 61830 0 0 {name=l1156 lab=GND}
C {SRAM/PIM_NOR.sym} 190 62000 0 0 {name=x280}
C {devices/lab_pin.sym} -30 61910 0 0 {name=l1157 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 61930 0 0 {name=l1158 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 62090 2 0 {name=l1159 lab=VDD}
C {devices/gnd.sym} 180 62090 0 0 {name=l1160 lab=GND}
C {SRAM/PIM_NOR.sym} 190 62220 0 0 {name=x281}
C {devices/lab_pin.sym} -30 62130 0 0 {name=l1161 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 62150 0 0 {name=l1162 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 62310 2 0 {name=l1163 lab=VDD}
C {devices/gnd.sym} 180 62310 0 0 {name=l1164 lab=GND}
C {SRAM/PIM_NOR.sym} 190 62450 0 0 {name=x282}
C {devices/lab_pin.sym} -30 62360 0 0 {name=l1165 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 62380 0 0 {name=l1166 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 62540 2 0 {name=l1167 lab=VDD}
C {devices/gnd.sym} 180 62540 0 0 {name=l1168 lab=GND}
C {SRAM/PIM_NOR.sym} 190 62710 0 0 {name=x283}
C {devices/lab_pin.sym} -30 62620 0 0 {name=l1169 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 62640 0 0 {name=l1170 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 62800 2 0 {name=l1171 lab=VDD}
C {devices/gnd.sym} 180 62800 0 0 {name=l1172 lab=GND}
C {SRAM/PIM_NOR.sym} 190 62970 0 0 {name=x284}
C {devices/lab_pin.sym} -30 62880 0 0 {name=l1173 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 62900 0 0 {name=l1174 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 63060 2 0 {name=l1175 lab=VDD}
C {devices/gnd.sym} 180 63060 0 0 {name=l1176 lab=GND}
C {SRAM/PIM_NOR.sym} 190 63190 0 0 {name=x285}
C {devices/lab_pin.sym} -30 63100 0 0 {name=l1177 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 63120 0 0 {name=l1178 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 63280 2 0 {name=l1179 lab=VDD}
C {devices/gnd.sym} 180 63280 0 0 {name=l1180 lab=GND}
C {SRAM/PIM_NOR.sym} 190 63420 0 0 {name=x286}
C {devices/lab_pin.sym} -30 63330 0 0 {name=l1181 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 63350 0 0 {name=l1182 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 240 63480 2 0 {name=l1183 lab=VDD}
C {devices/gnd.sym} 180 63510 0 0 {name=l1184 lab=GND}
C {SRAM/PIM_NOR.sym} 190 63590 0 0 {name=x287}
C {devices/lab_pin.sym} -30 63500 0 0 {name=l1185 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 63520 0 0 {name=l1186 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 63680 2 0 {name=l1187 lab=VDD}
C {devices/gnd.sym} 180 63680 0 0 {name=l1188 lab=GND}
C {SRAM/PIM_NOR.sym} 190 63850 0 0 {name=x288}
C {devices/lab_pin.sym} -30 63760 0 0 {name=l1189 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 63780 0 0 {name=l1190 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 63940 2 0 {name=l1191 lab=VDD}
C {devices/gnd.sym} 180 63940 0 0 {name=l1192 lab=GND}
C {SRAM/PIM_NOR.sym} 190 64070 0 0 {name=x289}
C {devices/lab_pin.sym} -30 63980 0 0 {name=l1193 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 64000 0 0 {name=l1194 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 64160 2 0 {name=l1195 lab=VDD}
C {devices/gnd.sym} 180 64160 0 0 {name=l1196 lab=GND}
C {SRAM/PIM_NOR.sym} 190 64300 0 0 {name=x290}
C {devices/lab_pin.sym} -30 64210 0 0 {name=l1197 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 64230 0 0 {name=l1198 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 64390 2 0 {name=l1199 lab=VDD}
C {devices/gnd.sym} 180 64390 0 0 {name=l1200 lab=GND}
C {SRAM/PIM_NOR.sym} 190 64560 0 0 {name=x291}
C {devices/lab_pin.sym} -30 64470 0 0 {name=l1201 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 64490 0 0 {name=l1202 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 64650 2 0 {name=l1203 lab=VDD}
C {devices/gnd.sym} 180 64650 0 0 {name=l1204 lab=GND}
C {SRAM/PIM_NOR.sym} 190 64820 0 0 {name=x292}
C {devices/lab_pin.sym} -30 64730 0 0 {name=l1205 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 64750 0 0 {name=l1206 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 64910 2 0 {name=l1207 lab=VDD}
C {devices/gnd.sym} 180 64910 0 0 {name=l1208 lab=GND}
C {SRAM/PIM_NOR.sym} 190 65040 0 0 {name=x293}
C {devices/lab_pin.sym} -30 64950 0 0 {name=l1209 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 64970 0 0 {name=l1210 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 65130 2 0 {name=l1211 lab=VDD}
C {devices/gnd.sym} 180 65130 0 0 {name=l1212 lab=GND}
C {SRAM/PIM_NOR.sym} 190 65270 0 0 {name=x294}
C {devices/lab_pin.sym} -30 65180 0 0 {name=l1213 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 65200 0 0 {name=l1214 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 65360 2 0 {name=l1215 lab=VDD}
C {devices/gnd.sym} 180 65360 0 0 {name=l1216 lab=GND}
C {SRAM/PIM_NOR.sym} 190 65510 0 0 {name=x295}
C {devices/lab_pin.sym} -30 65420 0 0 {name=l1217 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 65440 0 0 {name=l1218 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 65600 2 0 {name=l1219 lab=VDD}
C {devices/gnd.sym} 180 65600 0 0 {name=l1220 lab=GND}
C {SRAM/PIM_NOR.sym} 190 65770 0 0 {name=x296}
C {devices/lab_pin.sym} -30 65680 0 0 {name=l1221 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 65700 0 0 {name=l1222 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 65860 2 0 {name=l1223 lab=VDD}
C {devices/gnd.sym} 180 65860 0 0 {name=l1224 lab=GND}
C {SRAM/PIM_NOR.sym} 190 65990 0 0 {name=x297}
C {devices/lab_pin.sym} -30 65900 0 0 {name=l1225 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 65920 0 0 {name=l1226 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 66080 2 0 {name=l1227 lab=VDD}
C {devices/gnd.sym} 180 66080 0 0 {name=l1228 lab=GND}
C {SRAM/PIM_NOR.sym} 190 66220 0 0 {name=x298}
C {devices/lab_pin.sym} -30 66130 0 0 {name=l1229 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 66150 0 0 {name=l1230 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 66310 2 0 {name=l1231 lab=VDD}
C {devices/gnd.sym} 180 66310 0 0 {name=l1232 lab=GND}
C {SRAM/PIM_NOR.sym} 190 66480 0 0 {name=x299}
C {devices/lab_pin.sym} -30 66390 0 0 {name=l1233 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 66410 0 0 {name=l1234 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 66570 2 0 {name=l1235 lab=VDD}
C {devices/gnd.sym} 180 66570 0 0 {name=l1236 lab=GND}
C {SRAM/PIM_NOR.sym} 190 66740 0 0 {name=x300}
C {devices/lab_pin.sym} -30 66650 0 0 {name=l1237 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 66670 0 0 {name=l1238 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 66830 2 0 {name=l1239 lab=VDD}
C {devices/gnd.sym} 180 66830 0 0 {name=l1240 lab=GND}
C {SRAM/PIM_NOR.sym} 190 66960 0 0 {name=x301}
C {devices/lab_pin.sym} -30 66870 0 0 {name=l1241 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 66890 0 0 {name=l1242 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 67050 2 0 {name=l1243 lab=VDD}
C {devices/gnd.sym} 180 67050 0 0 {name=l1244 lab=GND}
C {SRAM/PIM_NOR.sym} 190 67190 0 0 {name=x302}
C {devices/lab_pin.sym} -30 67100 0 0 {name=l1245 sig_type=std_logic lab=WLB_C}
C {devices/lab_pin.sym} 70 67120 0 0 {name=l1246 sig_type=std_logic lab=WL_C}
C {devices/vdd.sym} 220 67280 2 0 {name=l1247 lab=VDD}
C {devices/gnd.sym} 180 67280 0 0 {name=l1248 lab=GND}
C {devices/vsource.sym} -1710 930 0 0 {name=v11 value=0}
C {devices/lab_pin.sym} -1710 860 1 0 {name=l97 sig_type=std_logic lab=WLB_C}
C {devices/vsource.sym} -1480 930 0 0 {name=v12 value=0}
C {devices/lab_pin.sym} -1480 840 1 0 {name=l98 sig_type=std_logic lab=WL_C}
C {devices/gnd.sym} -1480 1000 0 0 {name=l99 lab=GND}
C {devices/gnd.sym} -1710 1000 0 0 {name=l100 lab=GND}
